BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing a hypersonic Shuttle Entry rigid-body model
! This batch set creates Space Shuttle models during re-entry in the hypersonic region at 
! Mach: 25. The first vehicle model has its lateral outputs calculated in stability axes and
! used for LQR design because the vehicle is commanded to roll about the velocity vector. 
! The second vehicle model is in body axes and used in simulations. There are also two models 
! for calculating mixing logic matrices, a control surfaces mixing matrix without RCS firing,
! and a jet selection logic assuming analog jet thrust and that the jets are able to produce 
! both positive and negative thrusts. Separate low order vehicle models are also created for 
! longitudinal and lateral control design using the LQR method. The systems and matrices are 
! finally exported into Matlab.
!
Retain Matrix    : Combined Jet plus Aero-Surface Mixing Logic for Shuttle Orbiter Hypersonic Re-Entry
Flight Vehicle   : Shuttle Early Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR design                
Flight Vehicle   : Shuttle Early Hypersonic Re-Entry, Rigid Body Axes Model for Simulation          
Flight Vehicle   : Shuttle During Early Hypersonic Re-Entry, for Surface Mixing Logic                
Flight Vehicle   : Shuttle During Early Hypersonic Re-Entry, For Jet Mix Logic          
Mixing Matrix    : Mixing Logic for the 5 Control Surfaces
Mixing Matrix    : Mixing Logic for the 11 Shuttle Entry Jets 
System Connection: Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR (Incl K7mix)  
System Modificat : Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Pitch Axis
System Modificat : Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Lateral Axes
To Matlab Format : Mixing Logic for the 5 Control Surfaces
To Matlab Format : Mixing Logic for the 11 Shuttle Entry Jets
To Matlab Format : Shuttle Early Hypersonic Re-Entry, Rigid Body Axes Model for Simulation
To Matlab Format : Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Pitch Axis
To Matlab Format : Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Lateral Axes
-----------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Early Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR design
! The following vehicle model is a Space Shuttle vehicle during the early phase of atmospheric 
! re-entry where it is flying at a high angle of attack and it is using both RCS jets and  
! control surfaces for attitude control. This is a Stability Axes model with Turn Coordination
! included in the vehicle model and it will be used for LQR control design purposes.
Stability Axes Output,Attitude=Euler Angles, Without GAFD, With Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  7460.4       32.17        0.20896E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  804000.0,   7325110.0,   7564300.0,    0.0, 134502.5, 0.0
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -82.85,       0.0,         2.7
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  25.0        18640.0       4.0          245500.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -7.39        -1.14         0.0000      -12.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  40.0         0.0         -0.5          0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          39.15        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2680.0       35.0,        79.0
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -81.36,       0.0,         2.97,       -2.07e-10    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.103,  -0.007,   -0.4e-6, 0.8e-7,  0.0,   -0.001,   0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.023,    0.39,   0.0,   -0.54,    0.0,     0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -2.6,    -0.086,   -1.7,    0.0,    0.0,     0.0,    -0.24e-6
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.007,    0.0,   -0.65,   0.25,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.0012, -0.008,    0.0,    0.0,   -17.4,   0.4e-5,  -0.1e-7    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    -0.0011,   0.0,    0.26,  -1.1,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   No TWD

Control Surface No:  1                                                                     Left Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       +2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022     -0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0028      -0.0018       0.0006        0.0000       0.0000       0.0000    
Control Surface No:  2                                                                     Left Inbrd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000        +1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        820.3        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025     -0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0006      -0.0032       0.0001        0.0000       0.0000       0.0000    
Control Surface No:  3                                                                     Right Inbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000       -1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        785.0        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025      0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0006      -0.0032      -0.0001        0.0000       0.0000       0.0000    
Control Surface No:  4                                                                     Right Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       -2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022      0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0028      -0.0018      -0.0006        0.0000       0.0000       0.0000    
Control Surface No:  5                                                                     Vertical Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0          25.000      -25.000        90.000       20.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  59.0         254.38       2.0           6.1          100.15     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.008       -0.008         0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -133.3,       0.0,        -22.5
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00056      0.0022       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0016       0.0         -0.0028        0.0000       0.0000       0.0000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  : 11

RCS Jet No:  1     Back, Left, Up, +Z                             (three 800 lb jets)    : BLU Jet          Throttling        Node 16
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5          39.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,       -11.5,      -5.8   
RCS Jet No:  2     Back, Right, Up, +Z                            (three 800 lb jets)    : BRU Jet          Throttling        Node 11
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5         -131.3       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,        11.5,      -5.8   
RCS Jet No:  3     Back, Left, Down, -Z                           (three 800 lb jets)    : BLD Jet          Throttling        Node 17
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.5          89.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,       -10.2,      -2.23
RCS Jet No:  4     Back, Right, Down, -Z                          (three 800 lb jets)    : BRD Jet          Throttling        Node 12
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.4         -89.2        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,        10.2,      -2.23
RCS Jet No:  5     Back, Left, +Y                                 (three 800 lb jets)    : BL+Y Jet         Throttling        Node 18
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,       -12.2,      -3.5
RCS Jet No:  6     Back, Right, -Y                                (three 800 lb jets)    : BR-Y Jet         Throttling        Node 13
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,        12.2,      -3.5
RCS Jet No:  7     Front, Up, +Z                                    (two 800 lb jets)    : FU Jet           Throttling        Node 34
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -87.4          180.0       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -29.2,         0.0,        0.0
RCS Jet No:  8     Front, Down, -Z, +Roll                           (two 800 lb jets)    : FLD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         +90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        -4.37,       1.9
RCS Jet No:  9     Front, Down, -Z, -Roll                           (two 800 lb jets)    : FRD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         -90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        +4.37,       1.9
RCS Jet No: 10     Front, Left, +Y                                  (two 800 lb jets)    : FL Jet           Throttling        Node 33
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        -4.8,        2.7
RCS Jet No: 11     Front, Right, -Y                                 (two 800 lb jets)    : FR Jet           Throttling        Node 31
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        +4.8,        2.7

Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, (x,y,z)                                                        :  0

Number of Vane Sensors, (Alpha or Beta)                                                  :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  :  0
-----------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Early Hypersonic Re-Entry, Rigid Body Axes Model for Simulation
! This model is a rigid-body Space Shuttle vehicle model similar to the previous except 
! that the output rates are with respect to the vehicle body axes and the  
! "Turn Coordination" option is turned off. It will be used in 6-dof simulations
Body Axes Output,Attitude=Euler Angles, Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  7460.4       32.17        0.20896E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  804000.0,   7325110.0,   7564300.0,    0.0, 134502.5, 0.0
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -82.85,       0.0,         2.7
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  25.0        18640.0       4.0          245500.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -7.39        -1.14         0.0000      -12.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  40.0         0.0         -0.5          0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          39.15        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2680.0       35.0,        79.0
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -81.36,       0.0,         2.97,       -2.07e-10    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.103,  -0.007,   -0.4e-6, 0.8e-7,  0.0,   -0.001,   0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.023,    0.39,   0.0,   -0.54,    0.0,     0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -2.6,    -0.086,   -1.7,    0.0,    0.0,     0.0,    -0.24e-6
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.007,    0.0,   -0.65,   0.25,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.0012, -0.008,    0.0,    0.0,   -17.4,   0.4e-5,  -0.1e-7    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    -0.0011,   0.0,    0.26,  -1.1,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   No TWD

Control Surface No:  1                                                                     Left Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       +2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022     -0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0028      -0.0018       0.0006        0.0000       0.0000       0.0000    
Control Surface No:  2                                                                     Left Inbrd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000        +1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        820.3        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025     -0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0006      -0.0032       0.0001        0.0000       0.0000       0.0000    
Control Surface No:  3                                                                     Right Inbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000       -1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        785.0        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025      0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0006      -0.0032      -0.0001        0.0000       0.0000       0.0000    
Control Surface No:  4                                                                     Right Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       -2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022      0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0028      -0.0018      -0.0006        0.0000       0.0000       0.0000    
Control Surface No:  5                                                                     Vertical Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0          25.000      -25.000        90.000       20.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  59.0         254.38       2.0           6.1          100.15     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.008       -0.008         0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -133.3,       0.0,        -22.5
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00056      0.0022       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0016       0.0         -0.0028        0.0000       0.0000       0.0000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  : 11

RCS Jet No:  1     Back, Left, Up, +Z                             (three 800 lb jets)    : BLU Jet          Throttling        Node 16
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5          39.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,       -11.5,      -5.8   
RCS Jet No:  2     Back, Right, Up, +Z                            (three 800 lb jets)    : BRU Jet          Throttling        Node 11
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5         -131.3       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,        11.5,      -5.8   
RCS Jet No:  3     Back, Left, Down, -Z                           (three 800 lb jets)    : BLD Jet          Throttling        Node 17
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.5          89.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,       -10.2,      -2.23
RCS Jet No:  4     Back, Right, Down, -Z                          (three 800 lb jets)    : BRD Jet          Throttling        Node 12
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.4         -89.2        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,        10.2,      -2.23
RCS Jet No:  5     Back, Left, +Y                                 (three 800 lb jets)    : BL+Y Jet         Throttling        Node 18
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,       -12.2,      -3.5
RCS Jet No:  6     Back, Right, -Y                                (three 800 lb jets)    : BR-Y Jet         Throttling        Node 13
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,        12.2,      -3.5
RCS Jet No:  7     Front, Up, +Z                                    (two 800 lb jets)    : FU Jet           Throttling        Node 34
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -87.4          180.0       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -29.2,         0.0,        0.0
RCS Jet No:  8     Front, Down, -Z, +Roll                           (two 800 lb jets)    : FLD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         +90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        -4.37,       1.9
RCS Jet No:  9     Front, Down, -Z, -Roll                           (two 800 lb jets)    : FRD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         -90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        +4.37,       1.9
RCS Jet No: 10     Front, Left, +Y                                  (two 800 lb jets)    : FL Jet           Throttling        Node 33
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        -4.8,        2.7
RCS Jet No: 11     Front, Right, -Y                                 (two 800 lb jets)    : FR Jet           Throttling        Node 31
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        +4.8,        2.7

Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, (x,y,z)                                                        :  0

Number of Vane Sensors, (Alpha or Beta)                                                  :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  :  0
-----------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle During Early Hypersonic Re-Entry, for Surface Mixing Logic
! The following vehicle model is a Space Shuttle vehicle during the early phase of atmospheric 
! re-entry where it is flying at a high angle of attack and it is using both RCS jets and  
! control surfaces for attitude control. This is a Stability Axes model with Turn Coordination
! included in the vehicle model and it will be used for LQR control design purposes.
Stability Axes Output,Attitude=Euler Angles, Without GAFD, With Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  7460.4       32.17        0.20896E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  804000.0,   7325110.0,   7564300.0,    0.0, 134502.5, 0.0
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -82.85,       0.0,         2.7
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  25.0        18640.0       4.0          245500.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -7.39        -1.14         0.0000      -12.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  40.0         0.0         -0.5          0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          39.15        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2680.0       35.0,        79.0
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -81.36,       0.0,         2.97,       -2.07e-10    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.103,  -0.007,   -0.4e-6, 0.8e-7,  0.0,   -0.001,   0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.023,    0.39,   0.0,   -0.54,    0.0,     0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -2.6,    -0.086,   -1.7,    0.0,    0.0,     0.0,    -0.24e-6
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.007,    0.0,   -0.65,   0.25,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.0012, -0.008,    0.0,    0.0,   -17.4,   0.4e-5,  -0.1e-7    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    -0.0011,   0.0,    0.26,  -1.1,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   With TWD

Control Surface No:  1                                                                     Left Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       +2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022     -0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0028      -0.0018       0.0006        0.0000       0.0000       0.0000    
Control Surface No:  2                                                                     Left Inbrd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000        +1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        820.3        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025     -0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0006      -0.0032       0.0001        0.0000       0.0000       0.0000    
Control Surface No:  3                                                                     Right Inbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000       -1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        785.0        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025      0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0006      -0.0032      -0.0001        0.0000       0.0000       0.0000    
Control Surface No:  4                                                                     Right Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       -2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022      0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0028      -0.0018      -0.0006        0.0000       0.0000       0.0000    
Control Surface No:  5                                                                     Vertical Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0          25.000      -25.000        90.000       20.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  59.0         254.38       2.0           6.1          100.15     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.008       -0.008         0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -133.3,       0.0,        -22.5
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00056      0.0022       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0016       0.0         -0.0028        0.0000       0.0000       0.0000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  0  

Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, (x,y,z)                                                        :  0

Number of Vane Sensors, (Alpha or Beta)                                                  :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  :  0
------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for the 5 Control Surfaces             
! Mixing Logic Matrix for combining the five Space Shuttle control surfaces (inboard and
! outboard elevons and rudder) excluding the RCS jets to achieve 3 rotational accelerations
!
KSmix
Shuttle During Early Hypersonic Re-Entry, for Surface Mixing Logic
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle During Early Hypersonic Re-Entry, For Jet Mix Logic
! The following model is used for creating a Jet Selection mixing logic matrix that 
! is used to transform the roll, pitch, and yaw demands to a analog thrusts 
! for the 10 jets. Negative thrusts are allowed.
Stability Axes Output,Attitude=Euler Angles, Without GAFD, With Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  7460.4       32.17        0.20896E+08
Moments and products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  804000.0,   7325110.0,   7564300.0,    0.0, 134502.5, 0.0
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -82.85,       0.0,         2.7
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  25.0        18640.0       4.0          245500.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -7.39        -1.14         0.0000      -12.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  40.0         0.0         -0.5          0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          39.15        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehicle (Azim & Elev) angles, or Force (lb), location, Torque (ft-lb)  :  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2680.0       35.0,        79.0
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -81.36,       0.0,         2.97,       -2.07e-10    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.103,  -0.007,   -0.4e-6, 0.8e-7,  0.0,   -0.001,   0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.023,    0.39,   0.0,   -0.54,    0.0,     0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -2.6,    -0.086,   -1.7,    0.0,    0.0,     0.0,    -0.24e-6
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.007,    0.0,   -0.65,   0.25,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.0012, -0.008,    0.0,    0.0,   -17.4,   0.4e-5,  -0.1e-7    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    -0.0011,   0.0,    0.26,  -1.1,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  : 11

RCS Jet No:  1     Back, Left, Up, +Z                             (three 800 lb jets)    : BLU Jet          Throttling        Node 16
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5          39.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,       -11.5,      -5.8   
RCS Jet No:  2     Back, Right, Up, +Z                            (three 800 lb jets)    : BRU Jet          Throttling        Node 11
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5         -131.3       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,        11.5,      -5.8   
RCS Jet No:  3     Back, Left, Down, -Z                           (three 800 lb jets)    : BLD Jet          Throttling        Node 17
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.5          89.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,       -10.2,      -2.23
RCS Jet No:  4     Back, Right, Down, -Z                          (three 800 lb jets)    : BRD Jet          Throttling        Node 12
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.4         -89.2        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,        10.2,      -2.23
RCS Jet No:  5     Back, Left, +Y                                 (three 800 lb jets)    : BL+Y Jet         Throttling        Node 18
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,       -12.2,      -3.5
RCS Jet No:  6     Back, Right, -Y                                (three 800 lb jets)    : BR-Y Jet         Throttling        Node 13
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,        12.2,      -3.5
RCS Jet No:  7     Front, Up, +Z                                    (two 800 lb jets)    : FU Jet           Throttling        Node 34
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -87.4          180.0       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -29.2,         0.0,        0.0
RCS Jet No:  8     Front, Down, -Z, +Roll                           (two 800 lb jets)    : FLD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         +90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        -4.37,       1.9
RCS Jet No:  9     Front, Down, -Z, -Roll                           (two 800 lb jets)    : FRD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         -90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        +4.37,       1.9
RCS Jet No: 10     Front, Left, +Y                                  (two 800 lb jets)    : FL Jet           Throttling        Node 33
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        -4.8,        2.7
RCS Jet No: 11     Front, Right, -Y                                 (two 800 lb jets)    : FR Jet           Throttling        Node 31
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        +4.8,        2.7

Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, (x,y,z)                                                        :  0

Number of Vane Sensors, (Alpha or Beta)                                                  :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  :  0
------------------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA ..........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for the 11 Shuttle Entry Jets             
! The following Jet Selection mixing logic matrix is used to transform the roll, pitch, yaw     
! and Az accel demands to a analog thrusts for the 11 jets. Assuming that negative thrusts 
! are acceptable. The 5 control surfaces are not included in the mixing logic.
KJmix
Shuttle During Early Hypersonic Re-Entry, For Jet Mix Logic
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
Az  Normal  Acceleration Along Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR (Incl K7mix)
! The following is a modification of the previous Shuttle re-entry vehicle without TWD. 
! It is also a Stability Axes model with Turn Coordination included in the vehicle.
! The aero-surface and RCS jers mixing logic matrices KSmix and KJmix are included in a 
! block diagonal form (matric K7mix). This system will be used for LQR control design. 
! The system has two sets of input vectors, one vector input coming from the RCS controller, 
! and another from the control surfaces controller.          
Titles of Systems to be Combined
Title 1 Shuttle Early Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR design                                  
SYSTEM INPUTS TO SUBSYSTEM  1      Shuttle Early Hypersonic Re-Entry, Rigid Sta 
Via Matrix +K7mix                       Size ( 16 x  7)                         
......................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1   Shuttle Early Hypersonic Re-Entry, Rigid Stab
Via Matrix +I14                         Size ( 14 x 14)                         
......................................................................
Definitions of Inputs  =   7
P-dot Roll  RCS  Demand About X Axis                                           
Q-dot Pitch RCS  Demand About Y Axis                                           
R-dot Yaw   RCS  Demand About Z Axis                                           
Az Normal Acceler RCS Demand Along Z Axis                                           
P-dot Roll  Aero Demand About X Axis                                           
Q-dot Pitch Aero Demand About Y Axis                                           
R-dot Yaw   Aero Demand About Z Axis                                           
 
Definitions of Outputs =  14
Roll Attitude  (phi)  (radians)                                                              
Roll Rate   (p-stab)  (rad/sec)                                                              
Pitch Attitude (thet) (radians)                                                              
Pitch Rate  (q-stab)  (rad/sec)                                                              
Yaw  Attitude  (psi)  (radians)                                                              
Yaw  Rate   (r-stab)  (rad/sec)                                                              
Angle of attack, alfa, (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
CG Acceleration along X axis, (ft/sec^2)                                                     
CG Acceleration along Y axis, (ft/sec^2)                                                     
CG Acceleration along Z axis, (ft/sec^2)                                                     
----------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Pitch Axis
Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR (Incl K7mix)                           
! Modify the previous LQR design system by selecting only the pitch variables.
! Select only the pitch RCS & Surface inputs, and the pitch state-vector outputs                     
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2   4   6
Extract States :   3   4   7
Extract Outputs:   3   4   7  14
----------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Lateral Axes
Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR (Incl K7mix)                           
! Modify the previous LQR design system by selecting only the lateral variables.
! Select only the roll/yaw RCS and Aero-Surface inputs, and the roll/yaw 
! state-vector outputs.                    
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   3   5   7
Extract States :   2   6   8
Extract Outputs:   2   6   8
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for the 5 Control Surfaces             
Matrix KSmix
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for the 11 Shuttle Entry Jets                                                                                    
Matrix KJmix
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Early Hypersonic Re-Entry, Rigid Body Axes Model for Simulation                                                                                    
System
Vehicle_6dof
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Pitch Axis                                                                      
System
Vehi_Pdes
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Hypersonic Re-Entry, Rigid Stabil Axes Model for LQR, Lateral Axes                                                                                    
System
Vehi_Ldes
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
