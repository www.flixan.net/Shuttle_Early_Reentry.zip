System Input 13 to Subsystem  2, Input  2, Gain= 1.0                           Left Inboard Elev Deflect Command
System Input 14 to Subsystem  2, Input  3, Gain= 1.0                           Right Inboard Elev Deflect Command       
System Input 15 to Subsystem  2, Input  4, Gain= 1.0                           Right Outboard Elev Deflect Command       
System Input 16 to Subsystem  2, Input  5, Gain= 1.0                           Rudder Deflect  Command 
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3     Sensors
System Output  1 from Subsystem  3, Output  1, Gain= 1.0                       p
System Output  2 from Subsystem  3, Output  2, Gain= 1.0                       q
System Output  3 from Subsystem  3, Output  3, Gain= 1.0                       r
System Output  4 from Subsystem  3, Output  4, Gain= 1.0                       Nz-accelerat
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1     Selected Vehicle Outputs
System Output  5 from Subsystem  1, Output  7, Gain= 1.0                       Alpha
System Output  6 from Subsystem  1, Output  8, Gain= 1.0                       Beta
System Output  7 from Subsystem  1, Output  9, Gain= 1.0                       dH
System Output  8 from Subsystem  1, Output 10, Gain= 1.0                       V-dot
System Output  9 from Subsystem  1, Output 11, Gain= 1.0                       V-cross-range
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2     Actuators
System Output 10 from Subsystem  2, Output  1, Gain= 1.0                       delta-left-outb-elev
System Output 11 from Subsystem  2, Output  2, Gain= 1.0                       delta-left-inbd-elev
System Output 12 from Subsystem  2, Output  3, Gain= 1.0                       delta-right-inbd-elev
System Output 13 from Subsystem  2, Output  4, Gain= 1.0                       delta-right-outb-elev
System Output 14 from Subsystem  2, Output  5, Gain= 1.0                       delta-rudder
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                        Actuator deflect & Acceler to Vehicle                           
Subsystem  2, Output  1 to Subsystem  1, Input 12, Gain=  1.0                  Left Outboard Elev Deflect             
Subsystem  2, Output  2 to Subsystem  1, Input 13, Gain=  1.0                  Left Inboard Elev Deflect             
Subsystem  2, Output  3 to Subsystem  1, Input 14, Gain=  1.0                  Right Inboard Elev Deflect             
Subsystem  2, Output  4 to Subsystem  1, Input 15, Gain=  1.0                  Right Outboard Elev Deflect             
Subsystem  2, Output  5 to Subsystem  1, Input 16, Gain=  1.0                  Rudder Deflect             
Subsystem  2, Output  6 to Subsystem  1, Input 22, Gain=  1.0                  Left Outboard Elev Acceler  
Subsystem  2, Output  7 to Subsystem  1, Input 23, Gain=  1.0                  Left Inboard Elev Acceler  
Subsystem  2, Output  8 to Subsystem  1, Input 24, Gain=  1.0                  Right Inboard Elev Acceler  
Subsystem  2, Output  9 to Subsystem  1, Input 25, Gain=  1.0                  Right Outboard Elev Acceler  
Subsystem  2, Output 10 to Subsystem  1, Input 26, Gain=  1.0                  Rudder Acceler  
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                        Vehicle to Sensors
Subsystem  1, Output 12 to Subsystem  3, Input  1, Gain=  1.0                  roll gyro
Subsystem  1, Output 13 to Subsystem  3, Input  2, Gain=  1.0                  pitch gyro
Subsystem  1, Output 14 to Subsystem  3, Input  3, Gain=  1.0                  yaw gyro
Subsystem  1, Output 17 to Subsystem  3, Input  4, Gain=  1.0                  accelerometer
......................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                        Hinge Moments Feedback
Subsystem  1, Output 18 to Subsystem  2, Input  6, Gain=  1.0                  Left Outboard Elev HM
Subsystem  1, Output 19 to Subsystem  2, Input  7, Gain=  1.0                  Left Inboard Elev HM
Subsystem  1, Output 20 to Subsystem  2, Input  8, Gain=  1.0                  Right Inboard Elev HM
Subsystem  1, Output 21 to Subsystem  2, Input  9, Gain=  1.0                  Right Outboard Elev HM
Subsystem  1, Output 22 to Subsystem  2, Input 10, Gain=  1.0                  Rudder HM
......................................................................
Definitions of Inputs  =  17
RCS-1
RCS-2
RCS-3
RCS-4
RCS-5
RCS-6
RCS-7
RCS-8
RCS-9
RCS-10
RCS-11
Left Outboard Deflection Command (rad)
Left Inboard Deflection Command (rad)
Right Inboard Deflection Command (rad)
Right Outboard Deflection Command (rad)
Rudder Deflection Command (rad)
Wind Gust (ft/sec)
 
Definitions of Outputs =  14
Rate-Gyro Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro Yaw Rate   (Body) (rad/sec)                                                  
Accelerom along Z, (ft/sec^2) Translat. Accelerat.                                   
Angle of attack, alfa, (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Left Outboard Deflection (rad)
Left Inboard Deflection (rad)
Right Inboard Deflection (rad)
Right Outboard Deflection (rad)
Rudder Deflection (rad)
------------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle Actuators Sensors and Mix-Logic Combination
! The following interconnection combines the vehicle with the actuators
! and the mixing logic. It also closes the Hinge moments loop with the actuators
Titles of Systems to be Combined
Title 1 Vehicle Actuators and Sensors Combination
SYSTEM INPUTS TO SUBSYSTEM  1                                                  to Vehicle RCS inputs
Via Matrix +K7mix
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1
Via Matrix +I14
..............................................................................
Definitions of Inputs  =   7
P-dot Roll  RCS  Command About X Axis                                           
Q-dot Pitch RCS  Command About Y Axis                                           
R-dot Yaw   RCS  Command About Z Axis                                           
Az  Normal  Acceleration Along Z Axis                                           
P-dot Roll  Aero Command About X Axis                                           
Q-dot Pitch Aero Command About Y Axis                                           
R-dot Yaw   Aero Command About Z Axis                                           
 
Definitions of Outputs =  14
Rate-Gyro Roll Rate  (Body) (rad/sec)                                                  
Rate-Gyro Pitch Rate (Body) (rad/sec)                                                  
Rate-Gyro Yaw Rate   (Body) (rad/sec)                                                  
Accelerom along Z, (ft/sec^2) Translat. Accelerat.                                   
Angle of attack, alfa, (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Left Outboard Deflection (rad)
Left Inboard Deflection (rad)
Right Inboard Deflection (rad)
Right Outboard Deflection (rad)
Rudder Deflection (rad)
------------------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Vehicle Actuators Sensors and Mix-Logic Combination (Z-Transformed)                                 
! The following interconnection combines the vehicle with the actuators  and the mixing logic. It  
! also closes the Hinge moments loop with the actuators                                            
Vehicle Actuators Sensors and Mix-Logic Combination                                                 
From S-plane to Z-plane using the Z-Transform, dT=  0.40000E-01
----------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Vehicle Actuators Sensors and Mix-Logic Combination (Z-Transform with Delay)                        
! The following interconnection combines the vehicle with the actuators  and the mixing logic. It  
! also closes the Hinge moments loop with the actuators                                            
Vehicle Actuators Sensors and Mix-Logic Combination                                                 
From S-plane to Z-plane using the Z-Transform with Delay, dT, Delay=  0.40000E-01 0.20000E-01
----------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Vehicle Actuators Sensors and Mix-Logic Combination (Z-Transform with Delay)                                                                                    
System
Vehi_Sens_Actz
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Discrete Controller                                                                                    
System
Controller_z.m
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
