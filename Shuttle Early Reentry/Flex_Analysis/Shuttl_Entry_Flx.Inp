 Left Inboard Elevon Hinge Lin    1721    -0.74200D+00   0.25466D+00  -0.26039D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.76191D+00   0.28329D+00   0.11873D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.16565D+01   0.29611D+00   0.13510D+01   0.80248D-01   0.19474D+00  -0.62489D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.54016D-01   0.11830D+00  -0.39480D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.46547D+00   0.47432D+00   0.77528D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.54628D+00   0.44236D+00  -0.50383D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.33895D+00   0.56478D+00  -0.11861D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.39403D+00   0.57895D+00  -0.47701D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.54932D+00   0.67260D+00   0.32161D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.61198D+00   0.66345D+00  -0.57756D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.20883D-01   0.13748D+01  -0.22006D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.93282D-01   0.13749D+01  -0.19393D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.93282D-01   0.13749D+01  -0.19393D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.20740D+00   0.11927D+01  -0.33843D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.21950D+00   0.11872D+01   0.23273D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.73597D-02  -0.51824D+00   0.30773D+00  -0.20664D-01   0.39998D-01   0.36972D-01
 RATE GYRO  (for control)         1490    -0.73597D-02  -0.51824D+00   0.30773D+00  -0.20664D-01   0.39998D-01   0.36972D-01
 RATE GYRO  (for control)         1490    -0.73597D-02  -0.51824D+00   0.30773D+00  -0.20664D-01   0.39998D-01   0.36972D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.22076D+01  -0.20623D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.22076D+01  -0.20623D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.22076D+01  -0.20623D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.43210D-01   0.58352D-01   0.10801D+00  -0.44794D-01   0.85588D-01  -0.91661D-02

MODE #20/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.591       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.33041D+00  -0.13390D+00   0.73045D+00  -0.42446D-01   0.11153D+00   0.14194D-01
 Left Inboard Elevon Hinge Lin    1721     0.12454D+00  -0.13254D+00   0.90054D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.61165D-01  -0.71956D-01   0.23910D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.10223D+00  -0.72114D-01  -0.96575D-02  -0.29433D-02   0.10888D-01   0.38240D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.71737D-01   0.13029D+00  -0.27199D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.22333D+00   0.12056D+00   0.99340D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.27493D+00   0.54908D-01   0.25897D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.16807D+00   0.10528D+00   0.37735D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.20418D+00   0.27375D-02   0.25304D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.20082D+00   0.12023D+00   0.47366D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.24862D+00   0.12273D-01   0.33847D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.10436D+00  -0.82977D-01  -0.13500D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.10543D+00  -0.83896D-01  -0.15926D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.10543D+00  -0.83896D-01  -0.15926D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.62988D-01  -0.38525D-01  -0.57882D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.70729D-01  -0.46279D-01  -0.17310D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.28122D+00   0.15867D+00   0.12481D+01   0.79060D-01   0.21090D+00   0.39992D-02
 RATE GYRO  (for control)         1490    -0.28122D+00   0.15867D+00   0.12481D+01   0.79060D-01   0.21090D+00   0.39992D-02
 RATE GYRO  (for control)         1490    -0.28122D+00   0.15867D+00   0.12481D+01   0.79060D-01   0.21090D+00   0.39992D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.91001D-01  -0.21526D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.91001D-01  -0.21526D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.91001D-01  -0.21526D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.12861D+00   0.68057D-01  -0.12202D+00   0.24456D-01  -0.46873D-01  -0.30867D-01

MODE #21/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    59.870       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.10244D+00   0.88571D-02  -0.74574D-01  -0.22497D-01  -0.59085D-01   0.13892D-03
 Left Inboard Elevon Hinge Lin    1721    -0.10114D+00   0.77223D-02  -0.30086D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.81456D-02   0.40227D-02   0.14977D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.22861D-01   0.22670D-02   0.26691D+00   0.36547D-02   0.83934D-01  -0.68104D-03
 RUDDER NO.1 HINGE TAIL           2376    -0.15087D-01   0.17177D+00  -0.25350D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.34179D+00   0.94249D+00  -0.16071D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.30869D+00   0.47596D+00   0.81555D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.12189D+00   0.79723D+00  -0.15984D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.16956D+00   0.35173D+00   0.79132D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.35759D-01   0.10314D+01  -0.20457D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.16375D+00   0.46787D+00   0.10649D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.22307D-01   0.14639D+00  -0.67971D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18927D-01   0.14620D+00  -0.79868D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18927D-01   0.14620D+00  -0.79868D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.43536D-01   0.64919D-01  -0.16982D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.15096D-01   0.62790D-01   0.11685D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.29446D-01   0.51303D-01   0.12122D+00   0.19265D-01   0.10438D-01   0.16139D-02
 RATE GYRO  (for control)         1490    -0.29446D-01   0.51303D-01   0.12122D+00   0.19265D-01   0.10438D-01   0.16139D-02
 RATE GYRO  (for control)         1490    -0.29446D-01   0.51303D-01   0.12122D+00   0.19265D-01   0.10438D-01   0.16139D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.59058D+00  -0.58133D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.59058D+00  -0.58133D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.59058D+00  -0.58133D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.10321D+00  -0.60848D+00   0.10912D+00  -0.16349D+00   0.40146D-01   0.43892D+00

MODE #22/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    61.164       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.32822D-01  -0.79003D-01   0.14777D+00  -0.55883D-02   0.36795D-01   0.43783D-02
 Left Inboard Elevon Hinge Lin    1721    -0.15258D-01  -0.82126D-01   0.39390D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.11960D+00  -0.12989D+00   0.20267D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.32762D+00  -0.13484D+00  -0.55862D+00  -0.51638D-01  -0.11254D+00   0.14501D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.24617D-01   0.46141D+01   0.50398D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.26661D+00   0.14412D+00   0.19251D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.64999D-01  -0.90686D+00  -0.62102D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.18008D+00   0.16068D+00   0.21262D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.10551D+00  -0.89590D+00  -0.62848D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.25437D+00   0.18831D+00   0.24973D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.28567D+00  -0.10874D+01  -0.84046D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.26097D-01  -0.52524D-01   0.77278D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.22977D-01  -0.52836D-01   0.62095D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.22977D-01  -0.52836D-01   0.62095D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.51092D-03  -0.26236D-01   0.91889D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.16084D-01  -0.19788D-01   0.57285D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.77143D-01   0.40638D-01   0.17162D+00   0.13811D-01   0.26043D-01   0.67637D-03
 RATE GYRO  (for control)         1490    -0.77143D-01   0.40638D-01   0.17162D+00   0.13811D-01   0.26043D-01   0.67637D-03
 RATE GYRO  (for control)         1490    -0.77143D-01   0.40638D-01   0.17162D+00   0.13811D-01   0.26043D-01   0.67637D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.46958D-02  -0.30445D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.46958D-02  -0.30445D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.46958D-02  -0.30445D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.31713D-01  -0.20174D+00   0.68557D-01  -0.44823D-01  -0.16127D-01   0.21389D+00

MODE #23/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    61.359       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.54913D+00   0.21368D+00  -0.79240D+00   0.83300D-01  -0.15825D+00  -0.23678D-01
 Left Inboard Elevon Hinge Lin    1721    -0.20725D+00   0.20156D+00   0.40288D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.65954D-01   0.75089D-01   0.28286D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.13573D+00   0.69418D-01  -0.36274D+00  -0.48631D-01  -0.59290D-01   0.28189D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.14182D-01  -0.21655D+01   0.12932D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.30479D+00   0.10897D+01  -0.23979D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.39427D+00  -0.94007D+00  -0.27645D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.26506D+00   0.11033D+01  -0.23396D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.31479D+00  -0.93779D+00  -0.24778D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.49893D+00   0.13021D+01  -0.38831D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.57419D+00  -0.11513D+01  -0.40214D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.91013D-01   0.23526D-01   0.20846D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.92747D-01   0.23039D-01   0.23238D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.92747D-01   0.23039D-01   0.23238D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.74517D-02  -0.17821D-01   0.11029D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.26468D-02   0.33332D-02   0.19290D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.16603D+00  -0.19688D-01   0.30686D+00   0.34990D-01   0.55562D-01   0.20827D-02
 RATE GYRO  (for control)         1490    -0.16603D+00  -0.19688D-01   0.30686D+00   0.34990D-01   0.55562D-01   0.20827D-02
 RATE GYRO  (for control)         1490    -0.16603D+00  -0.19688D-01   0.30686D+00   0.34990D-01   0.55562D-01   0.20827D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17138D+00   0.22621D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17138D+00   0.22621D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17138D+00   0.22621D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.17432D+00   0.23183D+00   0.13406D+00   0.64599D-01  -0.77784D-01  -0.14504D+00

MODE #24/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    62.435       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.53696D+00   0.31371D+00  -0.12855D+01   0.84542D-01  -0.31669D+00  -0.26606D-01
 Left Inboard Elevon Hinge Lin    1721    -0.18573D+00   0.31967D+00   0.75311D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.17779D+00   0.31034D+00  -0.12207D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.53266D+00   0.30527D+00   0.13277D+01   0.89772D-01   0.31670D+00  -0.26243D-01
 RUDDER NO.1 HINGE TAIL           2376     0.30416D-01   0.30576D+01   0.24913D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.56619D+00   0.72751D+00   0.36102D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.77821D+00   0.96486D+00  -0.50456D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.33942D+00   0.91002D+00   0.33323D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.46844D+00   0.11755D+01  -0.48898D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.70246D+00   0.10812D+01   0.42681D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.93074D+00   0.13944D+01  -0.60611D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.86563D-03   0.32307D+00  -0.16113D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.88403D-03   0.32325D+00   0.12938D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.88403D-03   0.32325D+00   0.12938D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.39343D-01   0.28973D+00  -0.98901D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.35939D-01   0.29152D+00   0.10580D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.11553D-02   0.28624D+00  -0.45246D-02   0.10374D-01   0.49778D-03   0.29379D-03
 RATE GYRO  (for control)         1490    -0.11553D-02   0.28624D+00  -0.45246D-02   0.10374D-01   0.49778D-03   0.29379D-03
 RATE GYRO  (for control)         1490    -0.11553D-02   0.28624D+00  -0.45246D-02   0.10374D-01   0.49778D-03   0.29379D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.97282D+00   0.40137D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.97282D+00   0.40137D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.97282D+00   0.40137D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.95975D-01   0.59426D-01   0.15072D+00  -0.21418D-01   0.11582D-01  -0.10032D+00

MODE #25/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    62.886       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.45542D+00   0.27109D+00  -0.20484D+00  -0.32144D-01  -0.12913D+00  -0.18098D-01
 Left Inboard Elevon Hinge Lin    1721    -0.23439D+00   0.26968D+00  -0.43333D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.25671D+00   0.27943D+00   0.20113D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.57078D+00   0.28623D+00   0.53063D+00   0.71931D-02   0.18867D+00  -0.23098D-01
 RUDDER NO.1 HINGE TAIL           2376     0.41675D-01  -0.26311D+00  -0.12920D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.10407D+01  -0.92949D+00  -0.32493D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.66509D+00  -0.53003D+00  -0.25177D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.63489D+00  -0.11225D+01  -0.35251D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.40296D+00  -0.68122D+00  -0.22737D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.12407D+01  -0.14453D+01  -0.41867D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.84282D+00  -0.92406D+00   0.47356D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.28002D-01   0.43794D+00  -0.11968D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.31753D-01   0.43814D+00  -0.14755D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.31753D-01   0.43814D+00  -0.14755D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.14103D-01   0.25222D+00  -0.32912D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.26148D-02   0.24831D+00   0.24425D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.27714D-01  -0.22174D+00  -0.28512D-01   0.94697D-03  -0.88428D-02   0.83284D-02
 RATE GYRO  (for control)         1490     0.27714D-01  -0.22174D+00  -0.28512D-01   0.94697D-03  -0.88428D-02   0.83284D-02
 RATE GYRO  (for control)         1490     0.27714D-01  -0.22174D+00  -0.28512D-01   0.94697D-03  -0.88428D-02   0.83284D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.38951D+00   0.13013D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.38951D+00   0.13013D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.38951D+00   0.13013D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.40048D-01   0.69232D-01   0.14283D+00  -0.32267D-01   0.35593D-01   0.67632D-01

MODE #26/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.954       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.42021D+00   0.11092D+00  -0.59046D+00   0.17486D-01  -0.19678D+00  -0.13019D-01
 Left Inboard Elevon Hinge Lin    1721    -0.22429D+00   0.10213D+00  -0.18824D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.24713D+00  -0.91982D-01  -0.21644D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.46867D+00  -0.10241D+00  -0.71567D+00  -0.20622D-01  -0.23591D+00   0.13892D-01
 RUDDER NO.1 HINGE TAIL           2376     0.41309D+00  -0.17168D-01   0.25293D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.86555D+00  -0.54231D+00  -0.58544D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.88718D+00   0.58576D+00  -0.62580D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.53473D+00  -0.62413D+00  -0.65160D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.54479D+00   0.66892D+00  -0.69516D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.85711D+00  -0.75798D+00  -0.77878D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.87416D+00   0.80406D+00  -0.82901D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.11207D+00  -0.14927D+00   0.51902D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.11495D+00  -0.14920D+00   0.53572D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.11495D+00  -0.14920D+00   0.53572D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.57695D-01  -0.16090D+00   0.36263D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.38959D-01  -0.11166D+00   0.31744D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.37585D+00   0.68277D-01   0.54303D+00   0.73237D-01   0.19155D+00   0.44283D-02
 RATE GYRO  (for control)         1490    -0.37585D+00   0.68277D-01   0.54303D+00   0.73237D-01   0.19155D+00   0.44283D-02
 RATE GYRO  (for control)         1490    -0.37585D+00   0.68277D-01   0.54303D+00   0.73237D-01   0.19155D+00   0.44283D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.29486D+00   0.60699D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.29486D+00   0.60699D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.29486D+00   0.60699D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.15199D+00  -0.26665D-01   0.47598D-01  -0.21287D-01   0.22795D-01   0.19165D-01

MODE #27/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    66.069       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.84393D-15  -0.10668D-14  -0.13196D-13  -0.29492D-14  -0.93141D-14   0.62336D-15
 Left Inboard Elevon Hinge Lin    1721    -0.74180D-14  -0.79741D-16  -0.31021D-13   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.50891D-14   0.10655D-14   0.35374D-13   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.21903D-14  -0.16486D-15  -0.35892D-14  -0.33260D-14   0.41844D-14   0.44393D-15
 RUDDER NO.1 HINGE TAIL           2376     0.27449D-14   0.16816D-13   0.14465D-14   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.47213D-13  -0.63352D-13  -0.21519D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.56450D-13  -0.73697D-13   0.28714D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.28104D-13  -0.70280D-13  -0.24068D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.34507D-13  -0.80579D-13   0.32270D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.53516D-13  -0.83483D-13  -0.27679D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.62995D-13  -0.95550D-13   0.35903D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.23561D-14  -0.30278D-13   0.33761D-14   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.49924D-14  -0.30210D-13   0.89590D-14   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.49924D-14  -0.30210D-13   0.89590D-14   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.40112D-14  -0.34654D-13  -0.15975D-14   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.65942D-14  -0.34280D-13   0.66042D-14   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.16375D-14  -0.11399D-13  -0.11805D-13  -0.88254D-15  -0.20485D-14  -0.45969D-15
 RATE GYRO  (for control)         1490     0.16375D-14  -0.11399D-13  -0.11805D-13  -0.88254D-15  -0.20485D-14  -0.45969D-15
 RATE GYRO  (for control)         1490     0.16375D-14  -0.11399D-13  -0.11805D-13  -0.88254D-15  -0.20485D-14  -0.45969D-15

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.42080D-13   0.88188D-16
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.42080D-13   0.88188D-16
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.42080D-13   0.88188D-16

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.15723D-14   0.16055D-15  -0.56319D-14   0.53025D-14  -0.12829D-14  -0.41183D-14

MODE #28/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    66.756       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.60824D-01  -0.15909D+00  -0.97626D-01   0.10648D+00   0.11565D+00  -0.78724D-02
 Left Inboard Elevon Hinge Lin    1721     0.26516D+00  -0.18823D+00   0.11004D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.12560D+00  -0.14452D+00  -0.61946D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.26846D-01  -0.13457D+00  -0.74261D-02   0.58944D-01  -0.87949D-01  -0.42758D-02
 RUDDER NO.1 HINGE TAIL           2376     0.87885D-02  -0.12543D+01   0.43542D-03   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.15179D+01   0.20429D+01   0.72179D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.15974D+01   0.21050D+01  -0.82838D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.89614D+00   0.22155D+01   0.83540D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.93795D+00   0.22861D+01  -0.94999D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.16867D+01   0.26334D+01   0.92987D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.17599D+01   0.27146D+01  -0.10628D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.30745D-01   0.13382D+01   0.16485D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.82029D-01   0.13391D+01  -0.15475D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.82029D-01   0.13391D+01  -0.15475D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.18410D+00   0.14545D+01   0.76392D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.22071D+00   0.14567D+01  -0.67409D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.23662D-01   0.45618D+00   0.10411D+00   0.27945D-01   0.14535D-01   0.18144D-01
 RATE GYRO  (for control)         1490    -0.23662D-01   0.45618D+00   0.10411D+00   0.27945D-01   0.14535D-01   0.18144D-01
 RATE GYRO  (for control)         1490    -0.23662D-01   0.45618D+00   0.10411D+00   0.27945D-01   0.14535D-01   0.18144D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.20260D+01   0.46856D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.20260D+01   0.46856D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.20260D+01   0.46856D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.39979D-01   0.33048D-01   0.68814D-01  -0.69331D-01   0.84687D-02   0.10673D+00

MODE #29/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    68.488       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.28794D+00   0.57319D-01   0.12305D+01  -0.28839D+00   0.62116D-01   0.23892D-01
 Left Inboard Elevon Hinge Lin    1721    -0.89832D+00   0.13918D+00  -0.25103D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.36918D+00  -0.17267D+00   0.82755D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.57413D+00  -0.17527D+00  -0.10530D+01  -0.62130D-01  -0.35112D+00   0.13921D-01
 RUDDER NO.1 HINGE TAIL           2376     0.17879D+00  -0.80685D+00   0.15304D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.36922D+00   0.11241D+01  -0.71648D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.99166D+00   0.15113D+01  -0.13221D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.30911D+00   0.10957D+01  -0.67932D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.52508D+00   0.16136D+01  -0.23324D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.61999D+00   0.13771D+01  -0.92605D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.11580D+01   0.19765D+01  -0.24021D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.25692D+00   0.21477D+00   0.49159D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.22321D+00   0.21524D+00   0.44036D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.22321D+00   0.21524D+00   0.44036D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.90312D-01   0.27130D+00   0.38783D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.17149D-01   0.33226D+00   0.20503D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.42340D-01   0.11484D+00  -0.61964D+00  -0.22164D-01  -0.10071D+00   0.15181D-02
 RATE GYRO  (for control)         1490    -0.42340D-01   0.11484D+00  -0.61964D+00  -0.22164D-01  -0.10071D+00   0.15181D-02
 RATE GYRO  (for control)         1490    -0.42340D-01   0.11484D+00  -0.61964D+00  -0.22164D-01  -0.10071D+00   0.15181D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.41074D+00   0.17292D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.41074D+00   0.17292D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.41074D+00   0.17292D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.88360D-01   0.11387D+00   0.19578D+00   0.15052D-01  -0.70803D-02   0.87171D-01

MODE #30/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    68.572       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.67810D+00   0.13930D-01  -0.16376D+01   0.23006D+00  -0.36791D+00  -0.20466D-01
 Left Inboard Elevon Hinge Lin    1721    -0.19475D+00  -0.53639D-01   0.15673D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.55727D+00  -0.88567D-01  -0.48989D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.57438D+00  -0.10511D+00   0.21900D+00   0.14328D-01   0.24479D-01   0.31947D-02
 RUDDER NO.1 HINGE TAIL           2376     0.41457D+00   0.50256D+00   0.28654D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.11791D+01  -0.12679D+01  -0.10469D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.55008D+00  -0.27781D+00  -0.15689D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.51479D+00  -0.14447D+01  -0.11726D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.12992D+00  -0.14354D+00  -0.16353D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.11825D+01  -0.17274D+01  -0.14230D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.28365D+00  -0.22822D+00  -0.20561D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.18136D+00  -0.17022D+00   0.63699D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.18881D+00  -0.17119D+00   0.69329D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.18881D+00  -0.17119D+00   0.69329D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.12986D+00  -0.21439D+00   0.39178D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.55211D-01  -0.13363D+00   0.42283D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.22964D+00  -0.75524D-02  -0.68077D+00  -0.24024D-01  -0.13143D+00  -0.44253D-02
 RATE GYRO  (for control)         1490    -0.22964D+00  -0.75524D-02  -0.68077D+00  -0.24024D-01  -0.13143D+00  -0.44253D-02
 RATE GYRO  (for control)         1490    -0.22964D+00  -0.75524D-02  -0.68077D+00  -0.24024D-01  -0.13143D+00  -0.44253D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.18491D+00  -0.11418D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.18491D+00  -0.11418D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.18491D+00  -0.11418D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.23000D+00  -0.86038D-01   0.61160D-01  -0.10446D-01  -0.25926D-01  -0.76258D-01

MODE #31/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.232       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.60545D-01  -0.71676D-01  -0.68478D+00  -0.51101D-01  -0.33375D+00   0.98732D-02
 Left Inboard Elevon Hinge Lin    1721    -0.14722D+00  -0.13917D-01  -0.99009D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.44631D+00  -0.26168D+00  -0.21956D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.14502D-01  -0.19200D+00   0.14477D+01   0.28160D+00   0.18206D+00  -0.14843D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.15580D+00   0.39806D+00  -0.41820D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.52353D+00  -0.44541D+00   0.15324D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.34577D+00  -0.92418D+00  -0.12474D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.19617D+00  -0.35522D+00   0.15924D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.15518D+00  -0.95988D+00  -0.79921D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.26475D+00  -0.46333D+00   0.19507D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.46876D+00  -0.11628D+01  -0.13242D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.11906D+00  -0.49655D+00   0.10768D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.15645D+00  -0.49585D+00   0.59845D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.15645D+00  -0.49585D+00   0.59845D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.51923D-01  -0.49986D+00   0.13327D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.21274D+00  -0.49759D+00  -0.26555D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.15346D+00   0.93009D-01  -0.18023D+00   0.78843D-02  -0.82347D-02  -0.11552D-01
 RATE GYRO  (for control)         1490     0.15346D+00   0.93009D-01  -0.18023D+00   0.78843D-02  -0.82347D-02  -0.11552D-01
 RATE GYRO  (for control)         1490     0.15346D+00   0.93009D-01  -0.18023D+00   0.78843D-02  -0.82347D-02  -0.11552D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.46451D+00   0.10805D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.46451D+00   0.10805D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.46451D+00   0.10805D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.97890D-01  -0.21068D+00  -0.41843D-01  -0.28067D-01  -0.16359D-01  -0.10919D+00

MODE #32/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    70.100       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.30699D+00  -0.35835D+00  -0.47023D+00  -0.32692D-01  -0.22255D+00   0.26592D-01
 Left Inboard Elevon Hinge Lin    1721    -0.12357D-01  -0.33553D+00  -0.64095D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.51121D+00  -0.15312D+00   0.23206D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.10959D+00  -0.24330D+00   0.94154D-01  -0.21080D+00   0.32342D+00   0.35412D-01
 RUDDER NO.1 HINGE TAIL           2376     0.94020D-02  -0.51708D+00  -0.38437D-04   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.88876D+00   0.10023D+01   0.20460D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.10167D+01   0.10800D+01  -0.41749D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.52868D+00   0.10355D+01   0.30903D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.58324D+00   0.11303D+01  -0.53721D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.99823D+00   0.13175D+01   0.28319D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.11085D+01   0.14274D+01  -0.55260D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.13640D+00  -0.10235D+01  -0.86696D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.62536D-01  -0.10248D+01  -0.52834D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.62536D-01  -0.10248D+01  -0.52834D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.21114D+00  -0.90873D+00   0.99216D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.10979D+00  -0.92813D+00  -0.24697D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.37018D-01   0.34714D+00   0.16186D+00  -0.33163D-02   0.18930D-01  -0.16918D-01
 RATE GYRO  (for control)         1490    -0.37018D-01   0.34714D+00   0.16186D+00  -0.33163D-02   0.18930D-01  -0.16918D-01
 RATE GYRO  (for control)         1490    -0.37018D-01   0.34714D+00   0.16186D+00  -0.33163D-02   0.18930D-01  -0.16918D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.52702D+00  -0.10077D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.52702D+00  -0.10077D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.52702D+00  -0.10077D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.37708D-02  -0.10606D+00  -0.70887D-01   0.44004D-01  -0.61665D-02  -0.20921D-01

MODE #33/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    71.751       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.14836D+00  -0.33617D+00  -0.18020D+01   0.10430D+00  -0.61378D+00   0.15280D-01
 Left Inboard Elevon Hinge Lin    1721     0.26920D+00  -0.39520D+00   0.47226D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.37196D+00  -0.40342D+00  -0.11181D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.11185D+00  -0.33243D+00   0.18413D+01   0.17030D+00   0.53985D+00   0.73172D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.33854D-01  -0.46180D+00  -0.28624D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.67272D+00   0.20797D+01  -0.98814D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.49854D+00   0.19513D+01   0.10946D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.46710D+00   0.20840D+01  -0.91984D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.37591D+00   0.19277D+01   0.10386D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.10769D+01   0.25741D+01  -0.12539D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.90176D+00   0.23846D+01   0.14096D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.14098D-01  -0.68398D+00   0.43004D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.87336D-01  -0.68425D+00   0.11113D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.87336D-01  -0.68425D+00   0.11113D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.13394D+00  -0.62547D+00   0.78782D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.20558D+00  -0.62059D+00  -0.56846D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.36116D-01   0.10460D+00  -0.10982D+00  -0.68013D-01  -0.11969D-01  -0.50703D-02
 RATE GYRO  (for control)         1490     0.36116D-01   0.10460D+00  -0.10982D+00  -0.68013D-01  -0.11969D-01  -0.50703D-02
 RATE GYRO  (for control)         1490     0.36116D-01   0.10460D+00  -0.10982D+00  -0.68013D-01  -0.11969D-01  -0.50703D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.10001D+00  -0.16197D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.10001D+00  -0.16197D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.10001D+00  -0.16197D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.10163D-01   0.19762D+00  -0.19118D-01   0.12222D+00   0.63011D-02   0.80868D-01

MODE #34/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    72.359       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.29297D-02   0.20600D+00   0.88399D+00  -0.26522D-01   0.33355D+00  -0.85110D-02
 Left Inboard Elevon Hinge Lin    1721     0.19017D-01   0.20802D+00   0.11957D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.74419D-01   0.16998D+00  -0.16357D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.53865D-01   0.17769D+00  -0.79631D+00  -0.18700D-01  -0.30802D+00  -0.64549D-02
 RUDDER NO.1 HINGE TAIL           2376     0.72412D-02  -0.86870D+00   0.23657D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.10474D+01  -0.52333D+00  -0.60716D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.96308D+00  -0.43512D+00   0.56558D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.60455D+00  -0.72915D+00  -0.63997D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.56612D+00  -0.62546D+00   0.59161D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.10820D+01  -0.91004D+00  -0.87049D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.99321D+00  -0.78419D+00   0.80524D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.28106D-01   0.49960D+00   0.18380D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.40494D-02   0.50009D+00  -0.18749D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.40494D-02   0.50009D+00  -0.18749D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.79623D-01   0.46487D+00  -0.41676D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.80637D-01   0.46992D+00   0.85251D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.74961D-02  -0.30462D+00  -0.17615D-01  -0.27462D-01  -0.23299D-02   0.12414D-01
 RATE GYRO  (for control)         1490    -0.74961D-02  -0.30462D+00  -0.17615D-01  -0.27462D-01  -0.23299D-02   0.12414D-01
 RATE GYRO  (for control)         1490    -0.74961D-02  -0.30462D+00  -0.17615D-01  -0.27462D-01  -0.23299D-02   0.12414D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.27908D+00   0.18513D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.27908D+00   0.18513D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.27908D+00   0.18513D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.27263D-02   0.12353D+00   0.86865D-02   0.11279D-01  -0.13930D-02   0.22569D-01

MODE #35/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    73.781       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.40812D+00  -0.41157D+00   0.26200D+00  -0.72337D-01   0.30406D-01   0.32886D-01
 Left Inboard Elevon Hinge Lin    1721     0.18186D-01  -0.42503D+00  -0.69066D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.20137D-01  -0.36111D+00   0.66843D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.38344D+00  -0.37092D+00  -0.31468D+00  -0.71955D-01  -0.50697D-01   0.28039D-01
 RUDDER NO.1 HINGE TAIL           2376     0.18678D-01  -0.29215D+00   0.44684D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.69501D+00  -0.63393D+00  -0.71252D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.64105D+00  -0.69563D+00   0.53544D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.35280D+00  -0.78160D+00  -0.74451D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.33456D+00  -0.83918D+00   0.55757D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.70297D+00  -0.90857D+00  -0.92738D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.68277D+00  -0.98069D+00   0.70245D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.11523D-02  -0.10154D+00   0.42481D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.53780D-03  -0.10166D+00   0.34513D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.53780D-03  -0.10166D+00   0.34513D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.94778D-02  -0.71234D-01   0.66138D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.83027D-02  -0.66889D-01  -0.26168D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.14573D-01   0.49854D-01  -0.15033D-01  -0.18222D-02  -0.31574D-02  -0.13346D-03
 RATE GYRO  (for control)         1490    -0.14573D-01   0.49854D-01  -0.15033D-01  -0.18222D-02  -0.31574D-02  -0.13346D-03
 RATE GYRO  (for control)         1490    -0.14573D-01   0.49854D-01  -0.15033D-01  -0.18222D-02  -0.31574D-02  -0.13346D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.12002D-01  -0.71830D-02
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.12002D-01  -0.71830D-02
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.12002D-01  -0.71830D-02

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.23529D-01  -0.85751D-01  -0.30470D-01   0.17871D-01  -0.56627D-03  -0.19917D-01

MODE #36/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    75.020       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.90906D-02  -0.34399D-01  -0.89842D+00   0.18092D-01  -0.36928D+00   0.48535D-02
 Left Inboard Elevon Hinge Lin    1721     0.12821D+00  -0.80375D-01   0.12086D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.18324D+00   0.18886D+00   0.19024D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.94701D-01   0.14270D+00  -0.11053D+01  -0.30445D-01  -0.44403D+00  -0.10712D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.45249D-01  -0.31339D-01  -0.15127D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.61871D+00   0.13400D+01  -0.68554D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.64899D+00  -0.13356D+01  -0.60542D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.39528D+00   0.14431D+01  -0.66838D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.40231D+00  -0.14511D+01  -0.58745D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.90869D+00   0.17922D+01  -0.79528D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.92914D+00  -0.17979D+01  -0.69025D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.41563D+00   0.85822D-01   0.68869D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.39614D+00   0.88981D-01   0.72892D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.39614D+00   0.88981D-01   0.72892D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.23412D+00   0.35142D-01   0.38263D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.20996D+00   0.14563D+00   0.42376D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.14280D+00  -0.10417D-01  -0.35833D+00  -0.10540D-01  -0.49997D-01  -0.59106D-03
 RATE GYRO  (for control)         1490     0.14280D+00  -0.10417D-01  -0.35833D+00  -0.10540D-01  -0.49997D-01  -0.59106D-03
 RATE GYRO  (for control)         1490     0.14280D+00  -0.10417D-01  -0.35833D+00  -0.10540D-01  -0.49997D-01  -0.59106D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.38779D-01   0.23384D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.38779D-01   0.23384D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.38779D-01   0.23384D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.17776D+00  -0.53567D-02  -0.44444D+00  -0.73964D-01   0.60462D-01   0.15864D-02

MODE #37/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.122       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.98237D-01  -0.39227D-01  -0.16091D+01   0.12245D-01  -0.70528D+00   0.65745D-02
 Left Inboard Elevon Hinge Lin    1721     0.11411D+00  -0.10691D+00   0.83296D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.13565D+00   0.16702D+00   0.26244D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.13550D+00   0.97938D-01  -0.18813D+01  -0.34170D-01  -0.80225D+00  -0.63205D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.16589D+00   0.36054D-01  -0.11760D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.62278D+00   0.81099D+00  -0.39948D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.63953D+00  -0.75737D+00  -0.62265D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.43038D+00   0.85586D+00  -0.35936D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.47200D+00  -0.77241D+00  -0.57381D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.79781D+00   0.11049D+01  -0.44826D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.84460D+00  -0.10494D+01  -0.72327D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.19937D+00   0.69545D-01  -0.22553D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.19827D+00   0.70830D-01  -0.24721D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.19827D+00   0.70830D-01  -0.24721D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.18857D+00   0.71420D-01  -0.18447D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.15734D+00   0.46585D-01  -0.16859D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.22731D+00  -0.85889D-01  -0.60657D+00  -0.13278D-01  -0.55532D-01  -0.23194D-02
 RATE GYRO  (for control)         1490     0.22731D+00  -0.85889D-01  -0.60657D+00  -0.13278D-01  -0.55532D-01  -0.23194D-02
 RATE GYRO  (for control)         1490     0.22731D+00  -0.85889D-01  -0.60657D+00  -0.13278D-01  -0.55532D-01  -0.23194D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.10816D-02   0.26672D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.10816D-02   0.26672D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.10816D-02   0.26672D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.66812D-01   0.71624D-02   0.72594D-01   0.29509D-02   0.43869D-02   0.55937D-02

MODE #38/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    76.677       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.69267D-01  -0.45804D-01  -0.38318D+00  -0.23028D-01  -0.19049D+00   0.81497D-02
 Left Inboard Elevon Hinge Lin    1721     0.74379D-01  -0.83634D-01  -0.14758D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.81982D-01   0.55076D-01  -0.20203D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.52296D-01   0.43433D-01  -0.37761D+00   0.46720D-02  -0.17152D+00  -0.36061D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.25862D+00  -0.52557D-01  -0.90461D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.10308D+00  -0.18666D+01   0.18955D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.44888D-01   0.13181D+01   0.13557D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.74531D-01  -0.18693D+01   0.19578D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.58988D-01   0.13210D+01   0.13928D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.45932D+00  -0.23043D+01   0.24733D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.35758D+00   0.16444D+01   0.17584D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.87449D-01  -0.13931D-02  -0.91031D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.88170D-01  -0.61381D-03  -0.76738D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.88170D-01  -0.61381D-03  -0.76738D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.81507D-01  -0.39400D-02  -0.14084D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.84546D-01  -0.26825D-02  -0.92041D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.93332D-01   0.32180D-02  -0.91772D-01   0.52724D-03  -0.83179D-02  -0.15314D-02
 RATE GYRO  (for control)         1490     0.93332D-01   0.32180D-02  -0.91772D-01   0.52724D-03  -0.83179D-02  -0.15314D-02
 RATE GYRO  (for control)         1490     0.93332D-01   0.32180D-02  -0.91772D-01   0.52724D-03  -0.83179D-02  -0.15314D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.53392D-02   0.25535D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.53392D-02   0.25535D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.53392D-02   0.25535D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.50414D-02   0.10754D-01   0.16581D-01  -0.24065D+00   0.10381D-01  -0.58798D-01

MODE #39/ 39, Frequency (rad/sec), Damping (zeta), Generalized Mass=    78.174       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.56293D+00  -0.21505D+00   0.40966D+00  -0.14837D+00   0.34765D-01   0.52982D-01
 Left Inboard Elevon Hinge Lin    1721    -0.20550D-01  -0.36948D+00  -0.12980D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.30480D-01   0.37468D+00  -0.85983D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.48270D+00   0.32348D+00   0.51797D+00   0.92303D-01   0.13631D+00  -0.40984D-01
 RUDDER NO.1 HINGE TAIL           2376     0.97135D-01   0.10525D-01   0.81111D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.38148D+00  -0.61448D+00   0.97014D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.81608D-01  -0.29879D+00  -0.72111D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.31310D+00  -0.60511D+00   0.94119D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.12060D+00  -0.25586D+00  -0.70960D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.64658D+00  -0.89621D+00   0.11798D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.26993D+00  -0.43143D+00  -0.92614D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.38701D-01   0.13843D+00   0.64116D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.49868D-01   0.13781D+00   0.98806D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.49868D-01   0.13781D+00   0.98806D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.61193D-01   0.56144D-01  -0.59555D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.10524D+00   0.70446D-01   0.13524D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.13514D+00  -0.10797D+00   0.42780D-01   0.24215D-01   0.17917D-01   0.27956D-02
 RATE GYRO  (for control)         1490    -0.13514D+00  -0.10797D+00   0.42780D-01   0.24215D-01   0.17917D-01   0.27956D-02
 RATE GYRO  (for control)         1490    -0.13514D+00  -0.10797D+00   0.42780D-01   0.24215D-01   0.17917D-01   0.27956D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.14101D+00   0.50176D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.14101D+00   0.50176D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.14101D+00   0.50176D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.11500D+00   0.20521D+00   0.11344D+00  -0.72905D-01  -0.55999D-02   0.11457D-01

MODE #40/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    78.857       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.46694D-01   0.18439D-02  -0.32645D+00   0.51526D-03  -0.14811D+00  -0.64857D-03
 Left Inboard Elevon Hinge Lin    1721     0.10411D+00   0.87283D-02   0.72283D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.70946D-02  -0.35536D+00   0.85345D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.33217D+00  -0.24049D+00   0.32071D+00  -0.12314D+00   0.28176D+00   0.42982D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.62985D-01  -0.46624D-01   0.55300D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.71311D-01  -0.42509D-01   0.88669D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.77410D+00  -0.14062D+01  -0.17590D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.12626D+00  -0.26683D-01   0.89638D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.65271D+00  -0.14221D+01  -0.17264D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.28029D+00  -0.20144D+00   0.11044D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.13384D+01  -0.20133D+01  -0.21992D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.33539D-01   0.10162D+00  -0.10283D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.24535D-01   0.10218D+00  -0.52374D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.24535D-01   0.10218D+00  -0.52374D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.91197D-01  -0.76318D-02  -0.16921D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.42343D-01  -0.19379D-01   0.10117D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.86631D-01  -0.11891D+00   0.11070D+00   0.45690D-01   0.12225D-01  -0.17237D-02
 RATE GYRO  (for control)         1490     0.86631D-01  -0.11891D+00   0.11070D+00   0.45690D-01   0.12225D-01  -0.17237D-02
 RATE GYRO  (for control)         1490     0.86631D-01  -0.11891D+00   0.11070D+00   0.45690D-01   0.12225D-01  -0.17237D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.25134D+00   0.24658D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.25134D+00   0.24658D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.25134D+00   0.24658D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.66458D-01   0.34302D+00   0.11071D+00   0.31486D+00  -0.63787D-02   0.13948D+00

MODE #41/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    79.591       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.47823D-01   0.11587D-01   0.15706D+00  -0.22739D-01   0.59195D-01   0.89218D-03
 Left Inboard Elevon Hinge Lin    1721    -0.47754D-01  -0.21876D-01  -0.19646D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.50014D-01  -0.10617D+00   0.34249D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.24837D+00  -0.75122D-01   0.35199D-02  -0.42785D-01   0.48369D-01   0.18000D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.12870D-01   0.61727D-01  -0.40291D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.43984D+00  -0.54842D+00   0.19183D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.35563D+00   0.58779D+00   0.14890D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.27173D+00  -0.58326D+00   0.15426D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.24558D+00   0.61615D+00   0.12749D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.57296D+00  -0.78400D+00   0.21892D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.47158D+00   0.77239D+00   0.18963D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.60970D-01   0.72299D-01  -0.37587D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.63577D-01   0.71915D-01  -0.40059D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.63577D-01   0.71915D-01  -0.40059D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.32043D-01   0.51652D-01  -0.35243D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.54807D-01   0.43586D-01   0.25734D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.10772D-01  -0.80233D-01  -0.45854D-01  -0.66321D-02  -0.20460D-01   0.29223D-03
 RATE GYRO  (for control)         1490    -0.10772D-01  -0.80233D-01  -0.45854D-01  -0.66321D-02  -0.20460D-01   0.29223D-03
 RATE GYRO  (for control)         1490    -0.10772D-01  -0.80233D-01  -0.45854D-01  -0.66321D-02  -0.20460D-01   0.29223D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.36467D-01  -0.41932D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.36467D-01  -0.41932D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.36467D-01  -0.41932D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.11953D+00   0.21414D-01   0.42452D+00  -0.23007D+01   0.25347D-01  -0.62944D+00

MODE #42/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    80.839       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.21188D+00  -0.24429D-01   0.12036D+01   0.23970D-02   0.60310D+00   0.42882D-03
 Left Inboard Elevon Hinge Lin    1721    -0.18132D-01  -0.85392D-01  -0.65310D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.26715D-01   0.21936D+00  -0.86907D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.41553D+00   0.17382D+00   0.12443D+01   0.27054D-01   0.59941D+00  -0.13877D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.33185D+00  -0.39406D-01   0.89663D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.56211D-01  -0.33877D+00  -0.20108D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.15185D+00   0.19886D+00  -0.12296D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.14153D+00  -0.43700D+00  -0.21210D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.74759D-01   0.31137D+00  -0.13559D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.44375D-01  -0.48929D+00  -0.34596D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.15916D+00   0.39100D+00  -0.27041D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.56174D-01  -0.50112D-01  -0.15605D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.46904D-01  -0.50252D-01  -0.16803D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.46904D-01  -0.50252D-01  -0.16803D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.11931D-01  -0.29733D-01  -0.44671D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.34940D-01  -0.62639D-01  -0.71728D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.84586D-01   0.34953D-01   0.99840D-01   0.58243D-03  -0.50187D-02  -0.32222D-02
 RATE GYRO  (for control)         1490     0.84586D-01   0.34953D-01   0.99840D-01   0.58243D-03  -0.50187D-02  -0.32222D-02
 RATE GYRO  (for control)         1490     0.84586D-01   0.34953D-01   0.99840D-01   0.58243D-03  -0.50187D-02  -0.32222D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.34231D-02  -0.60274D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.34231D-02  -0.60274D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.34231D-02  -0.60274D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.10378D+00  -0.10611D-01   0.45305D+00   0.34844D+00  -0.39778D-01   0.87629D-01

MODE #43/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    81.856       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.18771D+00   0.20720D-01   0.82550D+00   0.41753D-01   0.44672D+00   0.80690D-03
 Left Inboard Elevon Hinge Lin    1721    -0.40819D-01  -0.19479D-01  -0.38017D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.53457D-01   0.24637D-01   0.42955D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.36190D-01   0.44462D-01   0.43472D+00  -0.49506D-01   0.26141D+00   0.79651D-02
 RUDDER NO.1 HINGE TAIL           2376     0.97300D-01   0.13566D+00   0.10743D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.73510D-01   0.44747D+00   0.16228D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.39243D-02  -0.64774D-01  -0.13723D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.68552D-01   0.47986D+00  -0.73649D-03   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.19126D-01  -0.21786D-01  -0.10713D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.16002D+00   0.55026D+00  -0.43225D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.20662D-01  -0.71754D-01  -0.17258D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.54936D-01   0.97719D-01   0.34513D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.51270D-01   0.98270D-01   0.47993D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.51270D-01   0.98270D-01   0.47993D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.35519D-01   0.53727D-01  -0.40019D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.16571D-01   0.65265D-01   0.68838D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.28752D-01  -0.11670D+00  -0.15584D+00  -0.72612D-02  -0.20170D-01   0.63236D-03
 RATE GYRO  (for control)         1490     0.28752D-01  -0.11670D+00  -0.15584D+00  -0.72612D-02  -0.20170D-01   0.63236D-03
 RATE GYRO  (for control)         1490     0.28752D-01  -0.11670D+00  -0.15584D+00  -0.72612D-02  -0.20170D-01   0.63236D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.41538D-01   0.12355D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.41538D-01   0.12355D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.41538D-01   0.12355D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.14577D+00   0.10385D-01  -0.16983D+00  -0.21336D+00   0.11780D-01  -0.53074D-01

MODE #44/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    82.454       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.21369D+00  -0.29322D-01  -0.11674D+01  -0.99229D-01  -0.65980D+00   0.16563D-01
 Left Inboard Elevon Hinge Lin    1721     0.28049D+00   0.23075D-01   0.27144D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.23851D+00  -0.51617D-01   0.35661D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.90670D-01  -0.34913D-02  -0.10093D+01   0.68210D-01  -0.56493D+00  -0.69098D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.65547D+00   0.22334D-01  -0.12036D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.47169D+00  -0.48172D+00   0.44665D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.46922D+00   0.54059D+00   0.41575D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.41726D+00  -0.50276D+00   0.47741D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.41016D+00   0.56827D+00   0.45193D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.36124D+00  -0.56892D+00   0.55914D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.35382D+00   0.63375D+00   0.53158D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.33747D-01   0.60312D-01  -0.20545D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.35992D-01   0.61050D-01  -0.22680D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.35992D-01   0.61050D-01  -0.22680D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.13516D+00   0.42618D-01  -0.11008D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.10216D+00   0.11338D-02  -0.39094D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.65874D-01  -0.96823D-02   0.66253D+00   0.64335D-01   0.11091D+00  -0.95070D-03
 RATE GYRO  (for control)         1490     0.65874D-01  -0.96823D-02   0.66253D+00   0.64335D-01   0.11091D+00  -0.95070D-03
 RATE GYRO  (for control)         1490     0.65874D-01  -0.96823D-02   0.66253D+00   0.64335D-01   0.11091D+00  -0.95070D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.73270D-01   0.80370D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.73270D-01   0.80370D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.73270D-01   0.80370D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.91938D-01   0.81060D-02   0.27768D-01  -0.89625D-01  -0.79172D-02  -0.23805D-01

MODE #45/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    83.914       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.16579D+00  -0.27940D+00  -0.25668D+00   0.54342D-02  -0.12386D+00   0.89635D-02
 Left Inboard Elevon Hinge Lin    1721     0.11968D+00  -0.17789D+00   0.29963D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.11233D+00  -0.11913D+00  -0.47345D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.52693D-01  -0.23015D+00   0.42711D+00   0.98145D-02   0.21150D+00   0.26955D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.12378D-01  -0.18156D-02   0.63221D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.10144D+01  -0.96612D-01  -0.93569D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.10402D+01  -0.10108D+00   0.92967D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.68845D+00  -0.33749D+00  -0.90808D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.72475D+00  -0.33136D+00   0.90461D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.98616D+00  -0.38116D+00  -0.12194D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.10124D+01  -0.37434D+00   0.12034D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.13006D-01  -0.55816D-01   0.14458D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.13621D-02  -0.55829D-01   0.10388D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.13621D-02  -0.55829D-01   0.10388D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.28353D-01  -0.56552D-01   0.51256D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.14286D-01  -0.55639D-01  -0.13639D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.24996D-02   0.37072D-01   0.14381D-01   0.20576D-01   0.41998D-02   0.74372D-03
 RATE GYRO  (for control)         1490     0.24996D-02   0.37072D-01   0.14381D-01   0.20576D-01   0.41998D-02   0.74372D-03
 RATE GYRO  (for control)         1490     0.24996D-02   0.37072D-01   0.14381D-01   0.20576D-01   0.41998D-02   0.74372D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.52520D-01  -0.24876D-03
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.52520D-01  -0.24876D-03
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.52520D-01  -0.24876D-03

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.12136D-01  -0.16160D+00  -0.28477D-02  -0.24547D+00  -0.26856D-04  -0.88682D-01

MODE #46/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    84.985       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.25532D+00   0.12603D+00   0.10666D+01   0.23266D+00   0.71999D+00  -0.40318D-01
 Left Inboard Elevon Hinge Lin    1721    -0.15983D+00   0.43219D-01  -0.22164D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.31396D+00   0.14650D-01   0.40216D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.36253D+00   0.13214D+00  -0.13530D+01   0.26683D+00  -0.90558D+00  -0.43432D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.14361D+00   0.41217D-01  -0.13808D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.32636D-01  -0.11399D+00  -0.27623D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.21644D+00  -0.18272D+00  -0.28931D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.77236D-01  -0.14244D+00  -0.29749D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.20139D+00  -0.16768D+00  -0.27544D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.17430D-01  -0.17465D+00  -0.35204D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.25232D+00  -0.21614D+00  -0.32155D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.33747D-01  -0.88564D+00   0.23150D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.97038D-01  -0.88636D+00   0.20290D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.97038D-01  -0.88636D+00   0.20290D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.16109D+00  -0.67137D+00   0.16409D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.30362D+00  -0.65411D+00  -0.36681D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.76122D-01   0.79384D+00  -0.10749D+00  -0.78650D-01  -0.80886D-02  -0.18872D-02
 RATE GYRO  (for control)         1490     0.76122D-01   0.79384D+00  -0.10749D+00  -0.78650D-01  -0.80886D-02  -0.18872D-02
 RATE GYRO  (for control)         1490     0.76122D-01   0.79384D+00  -0.10749D+00  -0.78650D-01  -0.80886D-02  -0.18872D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.59592D+00  -0.17654D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.59592D+00  -0.17654D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.59592D+00  -0.17654D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.72133D-03  -0.83425D-01  -0.25582D+00   0.51120D-01   0.43215D-02   0.10142D-01

MODE #47/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    85.530       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.11295D+00  -0.79013D+00  -0.59247D-01   0.73658D-01   0.18346D-01   0.10169D-01
 Left Inboard Elevon Hinge Lin    1721     0.37711D-01  -0.57620D+00   0.49222D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.85188D-02  -0.48507D+00  -0.67820D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.12565D+00  -0.69908D+00   0.37749D+00   0.22587D-01   0.19174D+00   0.26137D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.82990D-02   0.38740D-01  -0.22217D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.52462D+00   0.40715D+00  -0.82181D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.21511D+00   0.23087D+00   0.68602D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.51963D+00   0.26612D+00  -0.73845D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.27433D+00   0.68427D-01   0.61230D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.67365D+00   0.47057D+00  -0.10185D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.30315D+00   0.19015D+00   0.86717D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.13108D+00  -0.48836D+00   0.16434D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.13407D+00  -0.48761D+00   0.12955D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.13407D+00  -0.48761D+00   0.12955D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.31007D-01  -0.23772D+00   0.32437D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.13191D+00  -0.20536D+00  -0.34507D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.53676D-01   0.55267D+00  -0.17173D+00  -0.37218D-01  -0.94616D-02   0.81349D-03
 RATE GYRO  (for control)         1490     0.53676D-01   0.55267D+00  -0.17173D+00  -0.37218D-01  -0.94616D-02   0.81349D-03
 RATE GYRO  (for control)         1490     0.53676D-01   0.55267D+00  -0.17173D+00  -0.37218D-01  -0.94616D-02   0.81349D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.45033D+00  -0.86668D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.45033D+00  -0.86668D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.45033D+00  -0.86668D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.35155D-01  -0.18161D+00  -0.84601D-01  -0.29688D+00   0.45471D-02  -0.98839D-01

MODE #48/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    86.591       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.41343D+00   0.25308D-01   0.19634D+00   0.12829D+00   0.20081D+00   0.70681D-02
 Left Inboard Elevon Hinge Lin    1721     0.95204D-01   0.47533D-01   0.24114D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.96839D-01   0.12167D+00   0.12778D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.29466D-01   0.14635D+00   0.53644D+00  -0.31851D+00   0.51628D+00   0.23928D-01
 RUDDER NO.1 HINGE TAIL           2376     0.16938D+00  -0.10042D-01  -0.16958D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.73063D+00   0.94314D+00  -0.89936D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.74623D+00  -0.81836D+00  -0.12262D+01   0.00000D+00   0.00000D+00   0.00000D+00
