-----------------------------------------------------------------------------------------------------------------------------------------------------
                Shuttle vehicle during early phase of hypersonic atmospheric re-entry 
-----------------------------------------------------------------------------------------------------------------------------------------------------
BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing a hypersonic Shuttle Entry flexible vehicle model
! This batch set creates a Space Shuttle flexible model during hypersonic re-entry at Mach: 25. 
! It creates also two actuator models for the aero surfaces and converts the systems to Matlab
! format.
Flight Vehicle   : Space Shuttle Orbiter Flex Model during Early Re-Entry (for batch)                
Actuator Model   : Outboard Elevon Actuator
Actuator Model   : Inboard Elevon Actuator    
To Matlab Format : Space Shuttle Orbiter Flex Model during Early Re-Entry (for batch)
To Matlab Format : Outboard Elevon Actuator
To Matlab Format : Inboard Elevon Actuator
-----------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Space Shuttle Orbiter Flex Model during Early Re-Entry 
! The following vehicle model is a Space Shuttle vehicle during the early phase of atmospheric 
! re-entry where it is flying at a high angle of attack and it is using both RCS jets and  
! control surfaces for attitude control. This set uses an additional file (Shuttle_Orb.Gaf) that
! contains the GAFD and inertial coupling coefficients used in modeling aeroelasticity.
! It requires a GAFD data file.
!
Body Axes Output, Attitude=Euler Angles, Include GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  7460.4       32.17        0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  804000.0,   7325110.0,   7564300.0,    0.0, 134502.5, 0.0
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -82.85,       0.0,         2.7
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  25.0        18640.0       4.0          245500.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -7.39        -1.14         0.0000      -12.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  40.0         0.0         -0.5          0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          39.15        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2680.0       35.0,        79.0
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -81.36,       0.0,         2.97,       -2.07e-10    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.103,  -0.007,   -0.4e-6, 0.8e-7,  0.0,   -0.001,   0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.023,    0.39,   0.0,   -0.54,    0.0,     0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -2.6,    -0.086,   -1.7,    0.0,    0.0,     0.0,    -0.24e-6
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.007,    0.0,   -0.65,   0.25,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.0012, -0.008,    0.0,    0.0,   -17.4,   0.4e-5,  -0.1e-7    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    -0.0011,   0.0,    0.26,  -1.1,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   With TWD

Control Surface No:  1                                                                     Left Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       +2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022     -0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0028      -0.0018       0.0006        0.0000       0.0000       0.0000    
Control Surface No:  2                                                                     Left Inbrd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000        +1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        820.3        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025     -0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0006      -0.0032       0.0001        0.0000       0.0000       0.0000    
Control Surface No:  3                                                                     Right Inbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000       -1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        785.0        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025      0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0006      -0.0032      -0.0001        0.0000       0.0000       0.0000    
Control Surface No:  4                                                                     Right Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       -2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022      0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0028      -0.0018      -0.0006        0.0000       0.0000       0.0000    
Control Surface No:  5                                                                     Vertical Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0          25.000      -25.000        90.000       20.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  59.0         254.38       2.0           6.1          100.15     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.008       -0.008         0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -133.3,       0.0,        -22.5
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00056      0.0022       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0016       0.0         -0.0028        0.0000       0.0000       0.0000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  : 11

RCS Jet No:  1     Back, Left, Up, +Z                             (three 800 lb jets)    : BLU Jet          Throttling        Node 16
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5          39.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,       -11.5,      -5.8   
RCS Jet No:  2     Back, Right, Up, +Z                            (three 800 lb jets)    : BRU Jet          Throttling        Node 11
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5         -131.3       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,        11.5,      -5.8   
RCS Jet No:  3     Back, Left, Down, -Z                           (three 800 lb jets)    : BLD Jet          Throttling        Node 17
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.5          89.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,       -10.2,      -2.23
RCS Jet No:  4     Back, Right, Down, -Z                          (three 800 lb jets)    : BRD Jet          Throttling        Node 12
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.4         -89.2        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,        10.2,      -2.23
RCS Jet No:  5     Back, Left, +Y                                 (three 800 lb jets)    : BL+Y Jet         Throttling        Node 18
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,       -12.2,      -3.5
RCS Jet No:  6     Back, Right, -Y                                (three 800 lb jets)    : BR-Y Jet         Throttling        Node 13
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,        12.2,      -3.5
RCS Jet No:  7     Front, Up, +Z                                    (two 800 lb jets)    : FU Jet           Throttling        Node 34
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -87.4          180.0       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -29.2,         0.0,        0.0
RCS Jet No:  8     Front, Down, -Z, +Roll                           (two 800 lb jets)    : FLD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         +90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        -4.37,       1.9
RCS Jet No:  9     Front, Down, -Z, -Roll                           (two 800 lb jets)    : FRD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         -90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        +4.37,       1.9
RCS Jet No: 10     Front, Left, +Y                                  (two 800 lb jets)    : FL Jet           Throttling        Node 33
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        -4.8,        2.7
RCS Jet No: 11     Front, Right, -Y                                 (two 800 lb jets)    : FR Jet           Throttling        Node 31
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        +4.8,        2.7

Number of Gyros, (Attitude and Rate), Node 38                                            :  3
Gyro No 1 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Roll Rate               -48.4, 0.0,  7.5
Gyro No 2 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Pitch Rate              -48.4, 0.0,  7.5
Gyro No 3 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Yaw Rate                -48.4, 0.0,  7.5

Number of Accelerometers, (x,y,z)                                                        :  3
Acceleromet No 1 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  X-axis Acceleration     -32.2, 0.0, -1.04
Acceleromet No 2 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Y-axis Acceleration     -32.2, 0.0, -1.04
Acceleromet No 3 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Z-axis Acceleration     -32.2, 0.0, -1.04

Number of Vane Sensors, (Alpha or Beta)                                                  :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  : 50
Shuttle Early Hypersonic Atmospheric Re-Entry, First 50 Modes     
-----------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Space Shuttle Orbiter Flex Model during Early Re-Entry (for batch)
! The following vehicle model is a Space Shuttle vehicle during the early phase of atmospheric 
! re-entry where it is flying at a high angle of attack and it is using both RCS jets and  
! control surfaces for attitude control. This set uses an additional file (Shuttle_Orb.Gaf) that
! contains the GAFD and inertial coupling coefficients used in modeling aeroelasticity. This
! vehicle set is the same as above, but includes two additional statements at the bottom used  
! for selecting GAFD frequencies to match the modal frequencies. 
! It also selects GAFD surfaces to match this vehicle surfaces. It requires a GAFD data file.
!
Body Axes Output, Attitude=Euler Angles, Include GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  7460.4       32.17        0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  804000.0,   7325110.0,   7564300.0,    0.0, 134502.5, 0.0
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -82.85,       0.0,         2.7
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  25.0        18640.0       4.0          245500.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -7.39        -1.14         0.0000      -12.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  40.0         0.0         -0.5          0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          39.15        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2680.0       35.0,        79.0
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -81.36,       0.0,         2.97,       -2.07e-10    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.103,  -0.007,   -0.4e-6, 0.8e-7,  0.0,   -0.001,   0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.023,    0.39,   0.0,   -0.54,    0.0,     0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -2.6,    -0.086,   -1.7,    0.0,    0.0,     0.0,    -0.24e-6
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.007,    0.0,   -0.65,   0.25,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.0012, -0.008,    0.0,    0.0,   -17.4,   0.4e-5,  -0.1e-7    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    -0.0011,   0.0,    0.26,  -1.1,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   With TWD

Control Surface No:  1                                                                     Left Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       +2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022     -0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0028      -0.0018       0.0006        0.0000       0.0000       0.0000    
Control Surface No:  2                                                                     Left Inbrd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000        +1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        820.3        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6       -18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025     -0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0006      -0.0032       0.0001        0.0000       0.0000       0.0000    
Control Surface No:  3                                                                     Right Inbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -7.0          30.000      -35.000       -1.3          0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  100.0        785.0        2.5           8.594        134.96     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        18.4         11.1  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00025      0.0009      -0.008         0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0006      -0.0032      -0.0001        0.0000       0.0000       0.0000    
Control Surface No:  4                                                                     Right Outbd Elevon    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg): -5.0          30.000      -35.000       -2.5000       0.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  55.0         227.4        1.8           6.322        75.823     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -118.6        33.16        10.4  
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00022      0.0018      -0.0062        0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.0028      -0.0018      -0.0006        0.0000       0.0000       0.0000    
Control Surface No:  5                                                                     Vertical Rudder    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0          25.000      -25.000        90.000       20.000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  59.0         254.38       2.0           6.1          100.15     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.008       -0.008         0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}: -133.3,       0.0,        -22.5
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.00056      0.0022       0.0           0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0016       0.0         -0.0028        0.0000       0.0000       0.0000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  : 11

RCS Jet No:  1     Back, Left, Up, +Z                             (three 800 lb jets)    : BLU Jet          Throttling        Node 16
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5          39.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,       -11.5,      -5.8   
RCS Jet No:  2     Back, Right, Up, +Z                            (three 800 lb jets)    : BRU Jet          Throttling        Node 11
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -88.5         -131.3       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.1,        11.5,      -5.8   
RCS Jet No:  3     Back, Left, Down, -Z                           (three 800 lb jets)    : BLD Jet          Throttling        Node 17
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.5          89.3        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,       -10.2,      -2.23
RCS Jet No:  4     Back, Right, Down, -Z                          (three 800 lb jets)    : BRD Jet          Throttling        Node 12
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +82.4         -89.2        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -128.7,        10.2,      -2.23
RCS Jet No:  5     Back, Left, +Y                                 (three 800 lb jets)    : BL+Y Jet         Throttling        Node 18
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,       -12.2,      -3.5
RCS Jet No:  6     Back, Right, -Y                                (three 800 lb jets)    : BR-Y Jet         Throttling        Node 13
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           2400.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -88.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -131.2,        12.2,      -3.5
RCS Jet No:  7     Front, Up, +Z                                    (two 800 lb jets)    : FU Jet           Throttling        Node 34
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -87.4          180.0       0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -29.2,         0.0,        0.0
RCS Jet No:  8     Front, Down, -Z, +Roll                           (two 800 lb jets)    : FLD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         +90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        -4.37,       1.9
RCS Jet No:  9     Front, Down, -Z, -Roll                           (two 800 lb jets)    : FRD Jet          Throttling      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +50.0         -90.0        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -28.6,        +4.37,       1.9
RCS Jet No: 10     Front, Left, +Y                                  (two 800 lb jets)    : FL Jet           Throttling        Node 33
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          +91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        -4.8,        2.7
RCS Jet No: 11     Front, Right, -Y                                 (two 800 lb jets)    : FR Jet           Throttling        Node 31
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0           1600.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.5          -91.5        0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   1.0          1.0         1.0    
Thruster location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb,   (ft): -30.1,        +4.8,        2.7

Number of Gyros, (Attitude and Rate), Node 38                                            :  3
Gyro No 1 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Roll Rate               -48.4, 0.0,  7.5
Gyro No 2 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Pitch Rate              -48.4, 0.0,  7.5
Gyro No 3 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Yaw Rate                -48.4, 0.0,  7.5

Number of Accelerometers, (x,y,z)                                                        :  3
Acceleromet No 1 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  X-axis Acceleration     -32.2, 0.0, -1.04
Acceleromet No 2 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Y-axis Acceleration     -32.2, 0.0, -1.04
Acceleromet No 3 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Z-axis Acceleration     -32.2, 0.0, -1.04

Number of Vane Sensors, (Alpha or Beta)                                                  :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  : 50
Shuttle Early Hypersonic Atmospheric Re-Entry, First 50 Modes     
Selected GAFD Mode Numbers from GAFD File                                                :  1  2  3  4  5  6  7  8  9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 
Selected GAFD Surface Numbers from GAFD File                                             :  1  2  3  4  5  
-----------------------------------------------------------------------------------------------------------------------------------------------------
                            AERO-SURFACE ACTUATOR MODELS
-----------------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Outboard Elevon Actuator
! Hydraulic Actuator Type (B) for the Space Shuttle Outboard Elevon, Without Filter
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)   198.3
Kact   Actuator Gain .........................(ft/s/ft-lb)   0.06
Kt     Piston Ram Stiffness ...................  (lb/ft)     0.15E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      0.7226
Ie     Elevon Inertia about Gimbal ............(ft-lb-s^2)   227.6
Be     Elevon Viscous Damping .................(ft-lb-sec)   1450.0
Kb     Elevon Gimbal Bearing Spring Constant   (ft-lb/rad)   0.0
Kl     Elevon Mount Structural Stiffness ......  (lb/ft)     0.19E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)   0.12
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)   0.26E-03
Kfb    Position Feedback Gain ................. (rad/feet)   1.38396
-----------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Inboard Elevon Actuator
! Hydraulic Actuator Type (B) for the Space Shuttle Inboard Elevon
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)   198.3
Kact   Actuator Gain .........................(ft/s/ft-lb)   0.12
Kt     Piston Ram Stiffness ...................  (lb/ft)     0.46e+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      1.2
Ie     Rudder Inertia about Gimbal ............(ft-lb-s^2)   820.0
Be     Rudder Viscous Damping .............1250(ft-lb-sec)   3200.0
Kb     Rudder Gimbal Bearing Spring Constant   (ft-lb/rad)   0.0
Kl     Rudder Mount Structural Stiffness ......  (lb/ft)     0.38e+7
Tc     Different. Pressure Feedbk Time Constant  (seconds)   0.12
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)   0.26E-03
Kfb    Position Feedback Gain ................. (rad/feet)   0.8334
------------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR ALL AXES      
Shuttle Early Hypersonic Atmospheric Re-Entry, First 50 Modes     
! The first 50 flex modes modes were selected that correspond to the GAFD frequencies

MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.1779       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.38329D-01   0.32463D-02   0.45568D-01  -0.59548D-04  -0.89157D-03   0.65199D-04
 Left Inboard Elevon Hinge Lin    1721    -0.39217D-01   0.32014D-02   0.44843D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.40218D-01  -0.55768D-02   0.45595D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.40174D-01  -0.56246D-02   0.47212D-01   0.12074D-03  -0.90312D-03  -0.74039D-05
 RUDDER NO.1 HINGE TAIL           2376    -0.51453D-02  -0.68149D-03   0.32814D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.18018D-01  -0.10362D-02   0.30835D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.18538D-01  -0.81625D-03   0.31420D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.21845D-01  -0.12074D-02   0.29622D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.22273D-01  -0.86932D-03   0.30108D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.20146D-01  -0.11740D-02   0.27158D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.20741D-01  -0.92556D-03   0.27822D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.17500D-02   0.18328D-02   0.30856D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18498D-02   0.18263D-02   0.30874D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18498D-02   0.18263D-02   0.30874D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.21360D-01   0.14524D-02   0.30226D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.21701D-01   0.18937D-02   0.30271D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.44093D-01   0.12177D-02   0.20418D+00   0.35437D-03  -0.38225D-02   0.15265D-05
 RATE GYRO  (for control)         1490    -0.44093D-01   0.12177D-02   0.20418D+00   0.35437D-03  -0.38225D-02   0.15265D-05
 RATE GYRO  (for control)         1490    -0.44093D-01   0.12177D-02   0.20418D+00   0.35437D-03  -0.38225D-02   0.15265D-05

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17707D-02   0.30067D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17707D-02   0.30067D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17707D-02   0.30067D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.21664D-01  -0.82916D-03   0.40440D-01   0.68930D-05  -0.11568D-02   0.98251D-05

MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.4123       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.14980D-02   0.25739D-01  -0.45837D-01   0.13591D-02  -0.23226D-03   0.39841D-04
 Left Inboard Elevon Hinge Lin    1721     0.79257D-03   0.25735D-01  -0.25910D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.10889D-02   0.25925D-01   0.23770D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.17706D-02   0.25930D-01   0.43514D-01   0.13455D-02   0.19335D-03   0.38470D-04
 RUDDER NO.1 HINGE TAIL           2376     0.29254D-03   0.72404D-01  -0.12462D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.45508D-04   0.50427D-01  -0.15593D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.14987D-03   0.50420D-01   0.13115D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.24642D-04   0.46475D-01  -0.13330D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.11791D-03   0.46469D-01   0.10817D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.13907D-03   0.48322D-01  -0.17652D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.27494D-03   0.48314D-01   0.15075D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.18091D-03   0.65167D-01  -0.25017D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.27139D-03   0.65167D-01   0.19006D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.27139D-03   0.65167D-01   0.19006D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.10244D-02   0.56627D-01  -0.11376D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.11820D-02   0.56633D-01   0.10780D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.11672D-03   0.40670D-01  -0.46215D-03   0.16888D-02  -0.88153D-05   0.23556D-03
 RATE GYRO  (for control)         1490    -0.11672D-03   0.40670D-01  -0.46215D-03   0.16888D-02  -0.88153D-05   0.23556D-03
 RATE GYRO  (for control)         1490    -0.11672D-03   0.40670D-01  -0.46215D-03   0.16888D-02  -0.88153D-05   0.23556D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.63240D-01   0.90631D-03
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.63240D-01   0.90631D-03
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.63240D-01   0.90631D-03

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.16599D-04   0.45893D-01  -0.11698D-02   0.13395D-02  -0.22198D-04  -0.65797D-04

MODE # 3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.4221       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.16167D-02  -0.18839D-01  -0.36377D-01   0.11622D-02  -0.21528D-03  -0.41634D-04
 Left Inboard Elevon Hinge Lin    1721    -0.94495D-03  -0.18811D-01  -0.19474D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.52478D-03  -0.18389D-01   0.14826D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.12472D-02  -0.18415D-01   0.31432D-01   0.11403D-02   0.14650D-03  -0.44978D-04
 RUDDER NO.1 HINGE TAIL           2376     0.61513D-03   0.13540D-01  -0.26931D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.29588D-03  -0.20695D-03  -0.14282D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.18607D-03  -0.23570D-03   0.89457D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.14844D-03  -0.34700D-02  -0.12444D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.13934D-03  -0.35062D-02   0.70364D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.19802D-03  -0.20446D-02  -0.15973D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.16923D-03  -0.20819D-02   0.10452D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.18852D-03  -0.13502D-01  -0.24421D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.37447D-04  -0.13502D-01  -0.43784D-03   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.37447D-04  -0.13502D-01  -0.43784D-03   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.49599D-03  -0.17179D-01  -0.63855D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.25140D-03  -0.17183D-01   0.35038D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.14010D-03  -0.19968D-01  -0.15053D-02   0.85104D-03  -0.69682D-05  -0.69734D-04
 RATE GYRO  (for control)         1490    -0.14010D-03  -0.19968D-01  -0.15053D-02   0.85104D-03  -0.69682D-05  -0.69734D-04
 RATE GYRO  (for control)         1490    -0.14010D-03  -0.19968D-01  -0.15053D-02   0.85104D-03  -0.69682D-05  -0.69734D-04

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.14312D-01  -0.89590D-03
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.14312D-01  -0.89590D-03
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.14312D-01  -0.89590D-03

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.14365D-03  -0.35163D-02  -0.24780D-02   0.10290D-02  -0.35109D-04   0.62450D-04

MODE # 4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.4229       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.38707D-03   0.36240D-02   0.65336D-02  -0.12522D-03   0.51678D-04  -0.22706D-04
 Left Inboard Elevon Hinge Lin    1721    -0.61313D-04   0.36189D-02   0.47340D-02   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.62113D-03   0.30255D-02   0.17842D-02   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.87297D-03   0.30294D-02   0.32674D-03  -0.10046D-03   0.38483D-04  -0.17773D-04
 RUDDER NO.1 HINGE TAIL           2376    -0.84459D-03   0.73709D-03   0.37855D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.53439D-03   0.18106D-02   0.48064D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.13040D-03   0.18475D-02   0.26920D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.36388D-03   0.21283D-02   0.46810D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.33598D-04   0.21761D-02   0.29154D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.48502D-03   0.20356D-02   0.50760D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.22568D-04   0.20839D-02   0.26761D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.14981D-03   0.77652D-03   0.23084D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.18424D-03   0.77648D-03   0.20801D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.18424D-03   0.77648D-03   0.20801D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.83962D-04   0.12208D-02   0.27533D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.25575D-03   0.12242D-02   0.16204D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.18341D-03   0.20419D-02   0.22173D-02  -0.94277D-04   0.68375D-05  -0.13973D-04
 RATE GYRO  (for control)         1490     0.18341D-03   0.20419D-02   0.22173D-02  -0.94277D-04   0.68375D-05  -0.13973D-04
 RATE GYRO  (for control)         1490     0.18341D-03   0.20419D-02   0.22173D-02  -0.94277D-04   0.68375D-05  -0.13973D-04

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.91238D-03   0.21436D-02
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.91238D-03   0.21436D-02
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.91238D-03   0.21436D-02

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.20018D-03   0.19670D-02   0.35162D-02  -0.10073D-03   0.50855D-04  -0.16830D-04

MODE # 5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.8168       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.49449D-01   0.88502D-03  -0.29940D-02  -0.19397D-03   0.13310D-02  -0.73019D-04
 Left Inboard Elevon Hinge Lin    1721     0.50444D-01   0.93309D-03  -0.58777D-02   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.51706D-01   0.30708D-02  -0.96721D-02   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.51774D-01   0.31260D-02  -0.10585D-01  -0.67653D-04   0.13130D-02   0.12149D-06
 RUDDER NO.1 HINGE TAIL           2376     0.43189D-02  -0.12435D-02   0.10014D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.22598D-01   0.11854D-03   0.12685D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.23252D-01   0.37424D-03   0.10182D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.27842D-01   0.51878D-03   0.14252D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.28379D-01   0.75191D-03   0.12160D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.25573D-01   0.34592D-03   0.17855D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.26314D-01   0.73343D-03   0.15011D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.60172D-02  -0.31758D-02  -0.31967D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.61459D-02  -0.31681D-02  -0.32010D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.61459D-02  -0.31681D-02  -0.32010D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.29067D-01  -0.22885D-02  -0.31177D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.29520D-01  -0.28122D-02  -0.31346D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.55790D-01  -0.13263D-02  -0.19668D+00  -0.48461D-03   0.45372D-02  -0.78740D-05
 RATE GYRO  (for control)         1490     0.55790D-01  -0.13263D-02  -0.19668D+00  -0.48461D-03   0.45372D-02  -0.78740D-05
 RATE GYRO  (for control)         1490     0.55790D-01  -0.13263D-02  -0.19668D+00  -0.48461D-03   0.45372D-02  -0.78740D-05

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.29981D-02  -0.31058D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.29981D-02  -0.31058D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.29981D-02  -0.31058D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.27559D-01   0.36523D-03  -0.41967D-03  -0.11245D-03   0.17086D-02  -0.26443D-04

MODE # 6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.968       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.12687D+00   0.38863D+00  -0.11541D+00   0.14013D-02  -0.52872D-02  -0.42835D-02
 Left Inboard Elevon Hinge Lin    1721    -0.67344D-01   0.38730D+00  -0.88502D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.68253D-01   0.38685D+00   0.91999D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.12758D+00   0.38817D+00   0.11894D+00   0.14057D-02   0.53583D-02  -0.42650D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.31748D-03   0.11172D+01   0.20108D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.43983D-01   0.53815D+00  -0.61823D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.43682D-01   0.53807D+00   0.66832D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.37469D-01   0.53210D+00  -0.56084D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.37492D-01   0.53193D+00   0.61149D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.54963D-01   0.54858D+00  -0.71541D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.54839D-01   0.54844D+00   0.76896D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.14120D-02   0.56246D+00  -0.14024D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.46914D-04   0.56247D+00   0.17767D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.46914D-04   0.56247D+00   0.17767D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.35865D-02   0.50090D+00  -0.80178D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.25577D-02   0.50107D+00   0.84305D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.38633D-03   0.37200D+00   0.12516D-02   0.92209D-02  -0.39619D-04   0.17630D-02
 RATE GYRO  (for control)         1490     0.38633D-03   0.37200D+00   0.12516D-02   0.92209D-02  -0.39619D-04   0.17630D-02
 RATE GYRO  (for control)         1490     0.38633D-03   0.37200D+00   0.12516D-02   0.92209D-02  -0.39619D-04   0.17630D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.55676D+00   0.10566D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.55676D+00   0.10566D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.55676D+00   0.10566D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.86148D-03   0.47847D+00   0.87929D-03   0.49504D-02   0.27065D-03  -0.20871D-02

MODE # 7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.203       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.19872D-01  -0.77749D-01  -0.35423D+00   0.16027D-01   0.15194D-02  -0.97245D-03
 Left Inboard Elevon Hinge Lin    1721    -0.86760D-02  -0.76018D-01  -0.12930D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.99390D-02  -0.75372D-01   0.12120D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.20961D-01  -0.77038D-01   0.34090D+00   0.15637D-01  -0.20031D-02  -0.95613D-03
 RUDDER NO.1 HINGE TAIL           2376     0.17051D-02  -0.11813D+01  -0.26983D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.58574D-01   0.12596D+00  -0.29377D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.62501D-01   0.12673D+00   0.21060D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.44110D-01   0.10861D+00  -0.14370D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.47406D-01   0.10987D+00   0.61229D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.62969D-01   0.12802D+00  -0.35028D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.66656D-01   0.12918D+00   0.25984D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.11752D-03   0.30188D+00  -0.38041D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.40840D-02   0.30189D+00   0.46435D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.40840D-02   0.30189D+00   0.46435D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.96041D-02   0.14571D+00  -0.20676D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.12403D-01   0.14585D+00   0.21468D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.84215D-03  -0.23950D-01   0.12119D-03   0.33035D-01  -0.22852D-03  -0.72735D-03
 RATE GYRO  (for control)         1490     0.84215D-03  -0.23950D-01   0.12119D-03   0.33035D-01  -0.22852D-03  -0.72735D-03
 RATE GYRO  (for control)         1490     0.84215D-03  -0.23950D-01   0.12119D-03   0.33035D-01  -0.22852D-03  -0.72735D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.26801D+00   0.27739D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.26801D+00   0.27739D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.26801D+00   0.27739D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.10002D-02   0.66979D-01  -0.34399D-02   0.75037D-02  -0.92125D-03  -0.17451D-01

MODE # 8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.079       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.24336D+00  -0.18424D+00   0.11246D+01  -0.42546D-01   0.22027D-01   0.92400D-02
 Left Inboard Elevon Hinge Lin    1721     0.11169D+00  -0.18644D+00   0.50099D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.11864D+00  -0.18476D+00  -0.51358D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.24803D+00  -0.18270D+00  -0.11295D+01  -0.41959D-01  -0.22461D-01   0.90662D-02
 RUDDER NO.1 HINGE TAIL           2376     0.17502D-01   0.17194D+01  -0.22867D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.39155D-01  -0.67964D+00   0.21720D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.28183D-01  -0.68115D+00  -0.25266D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.26217D-01  -0.59415D+00   0.16327D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.19781D-01  -0.59658D+00  -0.20082D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.45683D-01  -0.64424D+00   0.25755D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.37448D-01  -0.64643D+00  -0.29703D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.77955D-03   0.76369D-01   0.78487D-02   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.13889D-01   0.76374D-01  -0.48861D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.13889D-01   0.76374D-01  -0.48861D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.32622D-01   0.17377D+00   0.11891D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.41037D-01   0.17366D+00  -0.15743D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.19433D-02   0.15250D+00  -0.73032D-02  -0.22747D-01   0.45750D-03   0.58283D-02
 RATE GYRO  (for control)         1490    -0.19433D-02   0.15250D+00  -0.73032D-02  -0.22747D-01   0.45750D-03   0.58283D-02
 RATE GYRO  (for control)         1490    -0.19433D-02   0.15250D+00  -0.73032D-02  -0.22747D-01   0.45750D-03   0.58283D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.97199D-01  -0.35367D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.97199D-01  -0.35367D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.97199D-01  -0.35367D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.48069D-02  -0.50457D+00  -0.14070D-01  -0.19779D-01  -0.85897D-03   0.94926D-02

MODE # 9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    27.414       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.45453D-15  -0.23980D-15   0.11071D-14   0.15400D-15   0.57738D-15   0.13092D-17
 Left Inboard Elevon Hinge Lin    1721     0.63340D-16  -0.14191D-15   0.14762D-15   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.33622D-15   0.16309D-16  -0.28316D-15   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.11711D-14   0.81825D-16   0.20692D-14   0.12027D-15   0.78431D-15  -0.23942D-16
 RUDDER NO.1 HINGE TAIL           2376     0.22125D-15  -0.28583D-15  -0.11801D-15   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.17964D-15  -0.27804D-14   0.14039D-14   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.54107D-15  -0.14088D-14   0.40388D-15   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.53548D-16  -0.30234D-14   0.14608D-14   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.50993D-15  -0.14087D-14   0.41541D-15   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.82111D-15  -0.36506D-14   0.17558D-14   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.68814D-15  -0.15658D-14   0.28552D-15   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.18512D-15   0.91802D-15  -0.23289D-15   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.19753D-15   0.91463D-15  -0.48788D-15   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.19753D-15   0.91463D-15  -0.48788D-15   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.16001D-16   0.92445D-15   0.28754D-16   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.20812D-15   0.91955D-15  -0.13319D-15   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.41703D-15   0.72869D-15   0.20134D-14   0.26186D-15   0.33459D-15   0.16479D-16
 RATE GYRO  (for control)         1490    -0.41703D-15   0.72869D-15   0.20134D-14   0.26186D-15   0.33459D-15   0.16479D-16
 RATE GYRO  (for control)         1490    -0.41703D-15   0.72869D-15   0.20134D-14   0.26186D-15   0.33459D-15   0.16479D-16

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.18221D-14   0.28660D-15
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.18221D-14   0.28660D-15
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.18221D-14   0.28660D-15

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.58412D-15   0.53110D-15   0.14166D-15   0.11320D-15  -0.15042D-15  -0.21929D-15

MODE #10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    30.023       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.10826D+00  -0.39378D-01  -0.16192D+01   0.66398D-01  -0.33779D-01  -0.99223D-02
 Left Inboard Elevon Hinge Lin    1721     0.24313D+00  -0.23825D-01  -0.65172D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.24334D+00   0.53026D-01  -0.74030D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.10400D+00   0.69556D-01  -0.18405D+01  -0.75300D-01  -0.42957D-01   0.10144D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.18514D+01  -0.39317D-02   0.13381D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.58282D+00  -0.22013D-01   0.50336D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.57355D+00   0.15480D-01   0.46747D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.36764D+00  -0.64152D-01   0.60156D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.35984D+00   0.69198D-01   0.57187D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.46789D+00  -0.39186D-01   0.68152D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.45696D+00   0.41576D-01   0.64100D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.67921D+00  -0.72237D-02   0.12961D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.67887D+00  -0.70138D-02   0.13038D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.67887D+00  -0.70138D-02   0.13038D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.38672D+00  -0.21538D-01   0.11625D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.39350D+00   0.22364D-02   0.11772D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.11512D+00   0.12065D-01  -0.22928D+00   0.10782D-01  -0.50510D-01  -0.19660D-02
 RATE GYRO  (for control)         1490     0.11512D+00   0.12065D-01  -0.22928D+00   0.10782D-01  -0.50510D-01  -0.19660D-02
 RATE GYRO  (for control)         1490     0.11512D+00   0.12065D-01  -0.22928D+00   0.10782D-01  -0.50510D-01  -0.19660D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.94616D-02   0.11935D+01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.94616D-02   0.11935D+01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.94616D-02   0.11935D+01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.29825D+00  -0.13541D-02   0.20930D+00  -0.18442D-02   0.63218D-01  -0.35117D-02

MODE #11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    34.056       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.32856D+00   0.27897D-01   0.33637D+01  -0.15678D+00   0.22110D+00  -0.64773D-02
 Left Inboard Elevon Hinge Lin    1721    -0.23739D+00   0.32525D-02   0.10773D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.26161D+00  -0.11979D-02  -0.91395D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.38941D+00   0.18640D-01  -0.27844D+01  -0.12712D+00  -0.18374D+00  -0.92248D-02
 RUDDER NO.1 HINGE TAIL           2376     0.57379D-01  -0.22211D-01  -0.62813D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.42908D+00   0.26243D+00   0.29298D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.45214D+00   0.25852D+00  -0.31302D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.33225D+00   0.37567D+00   0.26066D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.34683D+00   0.36424D+00  -0.28795D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.47644D+00   0.42326D+00   0.34735D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.49513D+00   0.41550D+00  -0.37150D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.77904D-02   0.68909D+00  -0.20636D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.68803D-01   0.68911D+00   0.36870D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.68803D-01   0.68911D+00   0.36870D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.19383D+00  -0.31264D+00  -0.13252D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.21953D+00  -0.30998D+00   0.14611D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.25575D-02  -0.86156D+00  -0.40758D-01   0.20264D+00  -0.68578D-02  -0.19616D-01
 RATE GYRO  (for control)         1490     0.25575D-02  -0.86156D+00  -0.40758D-01   0.20264D+00  -0.68578D-02  -0.19616D-01
 RATE GYRO  (for control)         1490     0.25575D-02  -0.86156D+00  -0.40758D-01   0.20264D+00  -0.68578D-02  -0.19616D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.29771D+00   0.23840D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.29771D+00   0.23840D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.29771D+00   0.23840D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.17978D-02   0.69869D-01  -0.32839D-01  -0.12358D-01  -0.37439D-02  -0.63791D-01

MODE #12/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    36.234       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.55066D+00   0.13543D-02   0.10805D+01  -0.49524D-01   0.89881D-01   0.74358D-02
 Left Inboard Elevon Hinge Lin    1721     0.44050D+00  -0.35319D-02   0.35027D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.42299D+00   0.67087D-02   0.45500D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.53336D+00  -0.11465D-02   0.14425D+01   0.66954D-01   0.11287D+00  -0.74529D-02
 RUDDER NO.1 HINGE TAIL           2376     0.89629D+00  -0.76174D-02  -0.74729D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.37013D+00  -0.15100D-01   0.20140D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.33861D+00  -0.29989D-01   0.22643D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.33892D+00   0.23394D-01  -0.12849D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.31306D+00  -0.72989D-01  -0.11007D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.36654D+00  -0.65867D-02   0.21192D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.32889D+00  -0.49879D-01   0.22898D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.62336D+00  -0.28634D-01   0.51108D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.61969D+00  -0.28241D-01   0.49296D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.61969D+00  -0.28241D-01   0.49296D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.48522D+00   0.11509D-02   0.48378D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.47022D+00   0.16694D-01   0.38271D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.33650D+00   0.48713D-01  -0.12470D+00   0.57354D-02  -0.14184D-01  -0.51722D-03
 RATE GYRO  (for control)         1490     0.33650D+00   0.48713D-01  -0.12470D+00   0.57354D-02  -0.14184D-01  -0.51722D-03
 RATE GYRO  (for control)         1490     0.33650D+00   0.48713D-01  -0.12470D+00   0.57354D-02  -0.14184D-01  -0.51722D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.12491D-01   0.41065D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.12491D-01   0.41065D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.12491D-01   0.41065D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.24247D+00  -0.89345D-02  -0.43755D-01  -0.41433D-02   0.22958D-01   0.11795D-02

MODE #13/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    38.157       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.47341D+00  -0.36662D-01  -0.50680D+01   0.28758D+00  -0.36271D+00  -0.28448D-01
 Left Inboard Elevon Hinge Lin    1721    -0.81188D-01   0.98626D-03  -0.99391D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.63100D-01   0.10062D-01  -0.11679D+01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.46095D+00   0.51769D-01  -0.56243D+01  -0.31218D+00  -0.39817D+00   0.28650D-01
 RUDDER NO.1 HINGE TAIL           2376     0.88472D+00   0.19223D-01  -0.53113D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.21562D+00   0.11151D-01   0.27374D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.26004D+00   0.71681D-01   0.26273D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.18590D+00   0.40636D-01   0.24648D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.22273D+00   0.52012D-01   0.23855D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.20257D+00   0.24282D-01   0.26279D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.25701D+00   0.77647D-01   0.25270D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.13603D+00   0.24598D-01  -0.51167D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.13040D+00   0.24498D-01  -0.48706D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.13040D+00   0.24498D-01  -0.48706D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.14491D-01  -0.17060D-01  -0.49561D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.96640D-02  -0.31637D-01  -0.36249D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.96861D-01  -0.37028D-01   0.30635D+00   0.12178D-01   0.35007D-01  -0.38290D-03
 RATE GYRO  (for control)         1490     0.96861D-01  -0.37028D-01   0.30635D+00   0.12178D-01   0.35007D-01  -0.38290D-03
 RATE GYRO  (for control)         1490     0.96861D-01  -0.37028D-01   0.30635D+00   0.12178D-01   0.35007D-01  -0.38290D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.60878D-03  -0.46204D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.60878D-03  -0.46204D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.60878D-03  -0.46204D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.16020D-01   0.13482D-01   0.61143D+00  -0.59331D-02   0.96547D-01  -0.59141D-02

MODE #14/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    40.638       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.32265D+00   0.86199D-01  -0.24842D+01   0.14607D+00  -0.21580D+00  -0.19357D-01
 Left Inboard Elevon Hinge Lin    1721    -0.59243D-01   0.10607D+00  -0.40218D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.14584D+00   0.97598D-01  -0.76765D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.23433D+00   0.10220D+00  -0.33222D+00  -0.17489D-01  -0.47409D-01  -0.65228D-02
 RUDDER NO.1 HINGE TAIL           2376    -0.87654D+00  -0.30225D+00   0.16692D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.17210D+00  -0.33479D+00   0.36307D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.30819D+00  -0.24582D+00  -0.26417D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.16467D+00  -0.30596D+00   0.34383D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.24473D+00  -0.13079D+00  -0.21934D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.18290D+00  -0.33263D+00   0.38296D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.27907D+00  -0.17408D+00  -0.37257D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.18731D+00   0.10552D+00  -0.75426D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.17924D+00   0.10533D+00  -0.71224D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.17924D+00   0.10533D+00  -0.71224D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.28581D-02   0.30900D-01  -0.73685D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.29165D-01   0.65851D-02  -0.50347D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.14650D+00  -0.45890D-01   0.53947D+00   0.21960D-01   0.59079D-01   0.32648D-03
 RATE GYRO  (for control)         1490     0.14650D+00  -0.45890D-01   0.53947D+00   0.21960D-01   0.59079D-01   0.32648D-03
 RATE GYRO  (for control)         1490     0.14650D+00  -0.45890D-01   0.53947D+00   0.21960D-01   0.59079D-01   0.32648D-03

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.81710D-01  -0.68650D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.81710D-01  -0.68650D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.81710D-01  -0.68650D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.37528D+00  -0.13230D+00  -0.42027D+00  -0.43683D-01  -0.13543D+00  -0.15369D-01

MODE #15/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    42.369       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.68950D+00   0.31387D+00  -0.26293D+01   0.17705D+00  -0.19707D+00  -0.33487D-01
 Left Inboard Elevon Hinge Lin    1721    -0.23643D+00   0.33044D+00  -0.13427D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.13884D+00   0.28428D+00   0.46682D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.43689D+00   0.26612D+00   0.22884D+01   0.12532D+00   0.21790D+00  -0.22449D-01
 RUDDER NO.1 HINGE TAIL           2376     0.46547D+00  -0.71687D+00  -0.87007D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.41819D+00  -0.64768D+00   0.12157D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.19185D+00  -0.69460D+00  -0.30139D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.30498D+00  -0.40323D+00   0.11130D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.18074D+00  -0.58805D+00  -0.23587D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.34005D+00  -0.52219D+00   0.14508D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.21121D+00  -0.65842D+00  -0.36389D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.16720D+00   0.71755D-01   0.67716D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.18279D+00   0.71990D-01   0.75404D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.18279D+00   0.71990D-01   0.75404D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.59582D-01  -0.53489D-01   0.43122D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.34829D-01  -0.27282D-01   0.76667D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.12331D+00  -0.42643D-01  -0.55388D+00   0.11902D-01  -0.61759D-01  -0.62849D-02
 RATE GYRO  (for control)         1490    -0.12331D+00  -0.42643D-01  -0.55388D+00   0.11902D-01  -0.61759D-01  -0.62849D-02
 RATE GYRO  (for control)         1490    -0.12331D+00  -0.42643D-01  -0.55388D+00   0.11902D-01  -0.61759D-01  -0.62849D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.75222D-02   0.71595D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.75222D-02   0.71595D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.75222D-02   0.71595D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.42482D+00  -0.30010D+00   0.55256D+00  -0.14126D+00   0.25747D+00  -0.46760D-01

MODE #16/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.335       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.50531D+00  -0.43471D+00   0.23043D+01  -0.14922D+00   0.22700D+00   0.27581D-01
 Left Inboard Elevon Hinge Lin    1721     0.14840D+00  -0.45083D+00   0.17699D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.17742D+00  -0.46194D+00  -0.12094D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.59483D+00  -0.44469D+00  -0.26827D+01  -0.17956D+00  -0.25032D+00   0.31638D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.44309D-01   0.94030D+00   0.37971D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.40362D-01   0.82655D+00  -0.89141D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.11958D+00   0.83225D+00   0.10328D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.25238D-02   0.61352D+00  -0.78277D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.79084D-01   0.59487D+00   0.90922D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.20350D-01   0.74010D+00  -0.10649D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.57607D-01   0.73446D+00   0.12178D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.27677D-01   0.14145D+00   0.15392D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18881D-01   0.14153D+00   0.25914D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18881D-01   0.14153D+00   0.25914D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.10848D+00   0.32242D+00   0.36014D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.14459D+00   0.32654D+00  -0.20376D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.28357D-01  -0.20517D-03  -0.73272D-01  -0.45607D-01  -0.76539D-02   0.14353D-01
 RATE GYRO  (for control)         1490    -0.28357D-01  -0.20517D-03  -0.73272D-01  -0.45607D-01  -0.76539D-02   0.14353D-01
 RATE GYRO  (for control)         1490    -0.28357D-01  -0.20517D-03  -0.73272D-01  -0.45607D-01  -0.76539D-02   0.14353D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.43465D+00   0.59347D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.43465D+00   0.59347D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.43465D+00   0.59347D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.34694D+00   0.31866D+00   0.74265D+00  -0.34044D-01   0.45964D+00  -0.92388D-02

MODE #17/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    46.773       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.27337D-14  -0.17492D-13   0.41633D-13  -0.20521D-14   0.60739D-14  -0.75965D-16
 Left Inboard Elevon Hinge Lin    1721    -0.44790D-15  -0.18262D-13   0.16891D-13   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.15828D-14  -0.24007D-13   0.72943D-14   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.20390D-13  -0.22964D-13  -0.16198D-12  -0.11944D-13  -0.15644D-13   0.14348D-14
 RUDDER NO.1 HINGE TAIL           2376     0.18376D-13   0.42124D-13  -0.92723D-14   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.19402D-13   0.51117D-13   0.13935D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.89259D-14   0.51933D-13   0.93833D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.13029D-13   0.47163D-13   0.18415D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.43446D-14   0.38249D-13   0.87481D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.20375D-13   0.53211D-13   0.14038D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.18511D-14   0.48401D-13   0.10861D-12   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.17238D-13   0.27085D-13   0.45446D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.13248D-13   0.27154D-13   0.37620D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.13248D-13   0.27154D-13   0.37620D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.14504D-13   0.35526D-13   0.49339D-13   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.72110D-14   0.37447D-13   0.18194D-13   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.17137D-14  -0.83850D-14  -0.57380D-13  -0.45276D-14  -0.73355D-14   0.10964D-14
 RATE GYRO  (for control)         1490     0.17137D-14  -0.83850D-14  -0.57380D-13  -0.45276D-14  -0.73355D-14   0.10964D-14
 RATE GYRO  (for control)         1490     0.17137D-14  -0.83850D-14  -0.57380D-13  -0.45276D-14  -0.73355D-14   0.10964D-14

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.56191D-13   0.39430D-13
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.56191D-13   0.39430D-13
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.56191D-13   0.39430D-13

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.15330D-13   0.22579D-13  -0.48014D-13   0.99680D-14  -0.34692D-13  -0.23653D-14

MODE #18/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    46.794       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.58251D-01   0.24189D+00  -0.49719D+00   0.16148D-01  -0.66029D-01   0.12423D-02
 Left Inboard Elevon Hinge Lin    1721     0.17072D-01   0.24773D+00  -0.23635D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.99342D-03   0.32836D+00  -0.14458D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.25378D+00   0.31490D+00   0.21419D+01   0.16319D+00   0.19280D+00  -0.19384D-01
 RUDDER NO.1 HINGE TAIL           2376    -0.21919D+00  -0.68230D+00   0.16101D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.30860D+00  -0.62748D+00  -0.24929D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.15813D+00  -0.68706D+00  -0.13552D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967     0.21677D+00  -0.57934D+00  -0.30869D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.87914D-01  -0.49844D+00  -0.12701D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969     0.31773D+00  -0.65800D+00  -0.25935D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.57442D-01  -0.63757D+00  -0.15649D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.23821D+00  -0.35746D+00  -0.63095D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18527D+00  -0.35805D+00  -0.53322D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.18527D+00  -0.35805D+00  -0.53322D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.18894D+00  -0.46746D+00  -0.68067D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.94521D-01  -0.49562D+00  -0.27033D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.71158D-02   0.10691D+00   0.69030D+00   0.60579D-01   0.81494D-01  -0.15489D-01
 RATE GYRO  (for control)         1490     0.71158D-02   0.10691D+00   0.69030D+00   0.60579D-01   0.81494D-01  -0.15489D-01
 RATE GYRO  (for control)         1490     0.71158D-02   0.10691D+00   0.69030D+00   0.60579D-01   0.81494D-01  -0.15489D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.78050D+00  -0.55080D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.78050D+00  -0.55080D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00  -0.78050D+00  -0.55080D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077    -0.19854D+00  -0.28280D+00   0.64979D+00  -0.12858D+00   0.48305D+00   0.27947D-01

MODE #19/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    47.364       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.15235D+01   0.27152D+00  -0.62534D+00   0.17730D-01  -0.12963D+00  -0.54735D-01
