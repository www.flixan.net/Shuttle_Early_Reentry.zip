 RCS THRUST POINT (BLD)           1967    -0.57017D+00   0.10543D+01  -0.90856D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.66676D+00  -0.84976D+00  -0.12170D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.10524D+01   0.13962D+01  -0.10615D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.10929D+01  -0.12062D+01  -0.14841D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988     0.71154D+00   0.39155D+00   0.55178D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.66607D+00   0.39954D+00   0.61176D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945     0.66607D+00   0.39954D+00   0.61176D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987     0.44639D+00   0.21887D+00  -0.61043D-01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944     0.31352D+00   0.39466D+00   0.25719D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490     0.24994D+00  -0.34497D+00  -0.92546D+00  -0.10785D-01  -0.74088D-01   0.11003D-02
 RATE GYRO  (for control)         1490     0.24994D+00  -0.34497D+00  -0.92546D+00  -0.10785D-01  -0.74088D-01   0.11003D-02
 RATE GYRO  (for control)         1490     0.24994D+00  -0.34497D+00  -0.92546D+00  -0.10785D-01  -0.74088D-01   0.11003D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17235D+00   0.51695D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17235D+00   0.51695D-01
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.17235D+00   0.51695D-01

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.24996D+00   0.58889D-01  -0.59218D+00  -0.83531D-02   0.24201D-01   0.14232D-01

MODE #49/ 49, Frequency (rad/sec), Damping (zeta), Generalized Mass=    90.304       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726    -0.14818D+01   0.30388D+00  -0.10776D+01   0.88930D+00  -0.24224D+00  -0.13372D+00
 Left Inboard Elevon Hinge Lin    1721    -0.57207D+00   0.28697D-01   0.50324D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571     0.43134D+00  -0.17005D-02  -0.92495D-01   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576     0.11142D+01   0.13227D+00   0.24009D+00   0.25194D+00   0.37837D-01  -0.68113D-01
 RUDDER NO.1 HINGE TAIL           2376     0.25083D+00   0.22457D-01   0.47622D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963     0.47504D-01   0.90069D+00  -0.10061D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893    -0.22942D+00  -0.18687D+00  -0.18151D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.60057D-01   0.92956D+00  -0.10595D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897    -0.14651D+00  -0.22680D+00  -0.17617D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.27410D+00   0.11633D+01  -0.13262D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899    -0.33057D+00  -0.34946D+00  -0.21568D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.18164D+00   0.52044D-01  -0.22343D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.17537D+00   0.49694D-01  -0.53383D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.17537D+00   0.49694D-01  -0.53383D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.27536D-02   0.17314D+00   0.21280D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.17397D+00   0.55379D-01  -0.49785D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.11460D+00   0.19442D+00   0.62292D+00   0.12114D+00   0.94826D-01  -0.11671D-01
 RATE GYRO  (for control)         1490    -0.11460D+00   0.19442D+00   0.62292D+00   0.12114D+00   0.94826D-01  -0.11671D-01
 RATE GYRO  (for control)         1490    -0.11460D+00   0.19442D+00   0.62292D+00   0.12114D+00   0.94826D-01  -0.11671D-01

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.24654D+00   0.31920D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.24654D+00   0.31920D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.24654D+00   0.31920D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.47967D-01   0.51270D-01  -0.96126D-01   0.15579D-03   0.56587D-03   0.81659D-02

MODE #50/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    91.872       0.50000E-02    7714.4    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
 Left Outboard Elevon Hinge Li    1726     0.97941D+00  -0.10247D+00  -0.13746D+01   0.82781D+00  -0.41463D+00  -0.18319D-01
 Left Inboard Elevon Hinge Lin    1721     0.41105D+00  -0.11269D+00   0.53521D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Inboard Elevon Hinge Li    1571    -0.53182D+00  -0.11670D+00   0.36481D+00   0.00000D+00   0.00000D+00   0.00000D+00
 Right Outboard Elevon Hinge L    1576    -0.15512D+01  -0.40602D+00  -0.10987D+01  -0.70588D+00  -0.38159D+00   0.12564D+00
 RUDDER NO.1 HINGE TAIL           2376     0.84798D-01  -0.18049D-01   0.60295D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the 11 Engines, (x,y,z)...
 RCS THRUST POINT (BLU)           1963    -0.31334D-01   0.50425D+00  -0.92186D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRU)           1893     0.25374D-02   0.63347D-01   0.46341D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BLD)           1967    -0.85235D-01   0.47173D+00  -0.92145D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BRD)           1897     0.31775D-01  -0.15920D-01   0.42757D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BL+Y)          1969    -0.27961D+00   0.69148D+00  -0.11818D+01   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUST POINT (BR-Y)          1899     0.78722D-01   0.74666D-01   0.58148D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FU)               2988    -0.39558D+00  -0.87011D-01  -0.48664D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.35756D+00  -0.93180D-01  -0.35801D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FLD & FRD)        2945    -0.35756D+00  -0.93180D-01  -0.35801D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FL-Y)             2987    -0.22907D+00  -0.17884D+00  -0.21718D+00   0.00000D+00   0.00000D+00   0.00000D+00
 RCS THRUSTER  (FR+Y)             2944    -0.11963D+00  -0.32475D+00   0.10864D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
 RATE GYRO  (for control)         1490    -0.14585D+00  -0.12541D+00   0.78020D+00   0.48212D-01   0.10487D+00   0.19659D-02
 RATE GYRO  (for control)         1490    -0.14585D+00  -0.12541D+00   0.78020D+00   0.48212D-01   0.10487D+00   0.19659D-02
 RATE GYRO  (for control)         1490    -0.14585D+00  -0.12541D+00   0.78020D+00   0.48212D-01   0.10487D+00   0.19659D-02

                              Node ID#     Modal Data at the  3 Accelerometers, along (x,y,z)...
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.47366D-01   0.18222D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.47366D-01   0.18222D+00
 CABIN ACCEL FWD BKHD (for con     307     0.00000D+00   0.47366D-01   0.18222D+00

                              Node ID#     Modal Data at the Disturbance Point 
 ENG.1 GIMBAL                     2077     0.10553D-01  -0.58539D-01  -0.16664D+00  -0.56500D-01  -0.30760D-02  -0.19023D-01
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Shuttle Orbiter Flex Model during Early Re-Entry (for batch)
System
Vehi_6dof_Flx
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Outboard Elevon Actuator                                                                                    
System
Outbd_Elev_Act
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Inboard Elevon Actuator                                                                                    
System
Inbd_Elev_Act
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
